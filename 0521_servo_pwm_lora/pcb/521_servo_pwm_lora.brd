# Repository FaBoPlatform/FaBo

## EAGLE design 0521_servo_pwm_lora/pcb/521_servo_pwm_lora.brd

Parts:
C1: 0.1uF; 0603-NARROW
JP1: PINHD-1X2; 1X02
LED1, LED2: LED-0603; 0603
LOGO1: LOGO_FABO-M_BOTTOM; LOGO_FABO_M_BOTTOM
PWM0, PWM1, PWM2, PWM3, PWM4: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
R1, R8: 470; 0603-NARROW
R11: 10k; 0603-NARROW
U$2: ARDUINO_MICRO_LORA
U$3: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
U$4: ES920LR

Connections:
3V3: C1.2, R1.2, R8.2, R11.2, U$2.3V3, U$4.2 (VCCRF), U$4.13 (VCC)
5V: PWM0.VCC, PWM1.VCC, PWM2.VCC, PWM3.VCC, PWM4.VCC, U$2.5V
GND: C1.1, JP1.2, PWM0.GND, PWM1.GND, PWM2.GND, PWM3.GND, PWM4.GND, U$2.GND1, U$4.1 (GND), U$4.26 (GND), U$4.GND
unnamed: LED2.CATHODE, U$4.19 (PTE16/PCS)
unnamed: LED1.CATHODE, U$4.20 (PTE17/SCK)
unnamed: LED1.ANODE, R1.1
unnamed: LED2.ANODE, R8.1
unnamed: R11.1, U$4.16 (PTC1/SW_INT)
PWM0: PWM0.I/O, U$2.A0
PWM1: PWM1.I/O, U$2.A1
PWM2: PWM2.I/O, U$2.A2
PWM3: PWM3.I/O, U$2.A3
PWM4: PWM4.I/O, U$2.A4
PWM5: U$2.A5
RESETB: U$2.D2, U$4.24 (RESETB)
RXD: U$2.TX1, U$4.9 (PTA1/RX)
SWD_CLK: U$4.5 (PTA0/SWD_CLK)
SWD_DIO: U$4.6 (PTA3/SWD_DIO)
TXD: U$2.RX1, U$4.8 (PTA2/TX)
VIN: JP1.1, U$2.VIN

Notes on the sheet:
1.0.0
PIN HEADER

Board: 2 copper layers, 27.9 x 90.2 mm, 16 parts (0 on the bottom side), 17 nets.

## EAGLE design 0522_outin_jetson_xavier/PCB/522_jetson_xavier.brd

Parts:
GPIO4, GPIO5: FABO_BRICK_3PIN-B03B-PASK-1_SILK; FABO_BRICK_3PIN_B03B-PASK-1_SILK
I2C: FABO_BRICK_I2C-B04B-PASK-1_SILK; FABO_BRICK_I2C_B04B-PASK-1_SILK
LOGO1: LOGO_FABO-M; LOGO_FABO_M
SERIAL: FABO_BRICK_SERIAL-B04B-PASK-1_SILK; FABO_BRICK_SERIAL_B04B-PASK-1_SILK
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
U$5: JETSON_NANO_NOBORDER; JETSON_NANO_NOBOARDER

Connections:
3V3: U$5.1 (3V3)
5V: GPIO4.VCC, GPIO5.VCC, I2C.VCC, SERIAL.VCC, U$5.2 (5V)
CE0: U$5.24 (CE0)
GND: GPIO4.GND, GPIO5.GND, I2C.GND, SERIAL.GND, U$5.6 (GND), U$5.9 (GND), U$5.14 (GND), U$5.20 (GND), U$5.25 (GND), U$5.30 (GND), U$5.34 (GND), U$5.39 (GND)
GPIO4: GPIO4.I/O, U$5.7 (GPIO4)
GPIO5: GPIO5.I/O, U$5.29 (GPIO5)
GPIO6: U$5.31 (GPIO6)
GPIO12: U$5.32 (GPIO12)
GPIO13: U$5.33 (GPIO13)
GPIO16: U$5.36 (GPIO16)
GPIO17: U$5.11 (GPIO17)
GPIO18: U$5.12 (GPIO18)
GPIO19: U$5.35 (GPIO19)
GPIO20: U$5.38 (GPIO20)
GPIO21: U$5.40 (GPIO21)
GPIO22: U$5.15 (GPIO22)
GPIO23: U$5.16 (GPIO23)
GPIO24: U$5.18 (GPIO24)
GPIO25: U$5.22 (GPIO25)
GPIO26: U$5.37 (GPIO26)
GPIO27: U$5.13 (GPIO27)
MISO: U$5.21 (MISO)
MOSI: U$5.19 (MOSI)
RX: SERIAL.RX, U$5.10 (RX)
SCL: I2C.SCL, U$5.5 (SCL)
SCLK: U$5.23 (SCLK)
SDA: I2C.SDA, U$5.3 (SDA)
TX: SERIAL.TX, U$5.8 (TX)

Notes on the sheet:
1.0.0
Jetson Nano
PIN HEADER
I2C (4pin 2mm pitch) x2
I2C
Serial (4pin Side 2mm pitch)

Board: 2 copper layers, 55.9 x 22.9 mm, 8 parts (0 on the bottom side), 8 nets.

Other parts of the board:
U$4: MARK_POINT_3MM

## EAGLE design 0523_outin_jetbook/pcb/523_jetson_jetbook.brd

Parts:
C1, C2, C3: 10uF; 0603-BOTTOM
C4, C5, C6, C7: 1uF; 0603-BOTTOM
C8, C9, C10, C11: 0.1uF; 0603
C12: CAPACITOR-0603; 0603
CAN: FABO_BRICK_CAN; FABO_BRICK_3PIN_B03B-PASK-1-CAN
CH0, CH1, CH2: FABO_BRICK_3PIN-B03B-PASK-1; FABO_BRICK_3PIN_B03B-PASK-1
D1: 1N4148; 1N4148W
GPIO4, GPIO5, GPIO6, GPIO12, GPIO13, GPIO16: FABO_BRICK_3PIN-B03B-PASK-1; FABO_BRICK_3PIN_B03B-PASK-1
I2C0, I2C1, I2C2: FABO_BRICK_I2C-B04B-PASK-1; FABO_BRICK_I2C_B04B-PASK-1
IC1: PCA9306_SSOP; 8PIN-SSOP
IC2: TXS0108; R-PUSON-N20
IC3: MICROCHIP-MCP3008
JETSON: FABO_BRICK_CAN_4P; FABO_BRICK_CAN_B04B-PASL-1_BOTTOM
LOGO1: LOGO_FABO-M; LOGO_FABO_M
PWM0, PWM1, PWM2, PWM3: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
R1, R2: 10k; EXBV8V
R3: 220; EXBV8V
R4, R10, R14: 4.7K; 0603-BOTTOM
R5: 390K; 0603-BOTTOM
R6: 100; 0603-BOTTOM
R7: 10K; 0603-BOTTOM
R8: 10K; EXBV8V
R9: 200K; 0603
R11, R12, R17: 9.1K; 0603-BOTTOM
R13: 1M; 0603-BOTTOM
R15: 120; 0603
R16: 20K; 0603-BOTTOM
R18: 10K; 0603
SERIAL: FABO_BRICK_SERIAL-B04B-PASK-1; FABO_BRICK_SERIAL_B04B-PASK-1
SJ1: SJ2W; SJ_2
SJ2, SJ3, SJ4: SMD-JUMPER-3-23SHORT; SMD-JUMPER-3
U1: ER-OLED0.96-1ER-CON30HT-1; ER-CON30HT-1
U$2: JETSON_NANO_NORBORDER_BOTTOM; JETSON_NANO_NOBOARDER_BOTTOM
U$7: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
U$8: SN65HVD230
U$9: PCA9685

Connections:
3V3: C6.2, C7.2, C8.2, C10.2, C12.2, D1.CATHODE, IC1.2 (VREF1), IC2.2 (VCCA), R7.2, R8.5 (2), R8.6 (2), R16.2, SJ1.3, SJ2.3, SJ3.1, SJ4.3, U1.22 (VDD), U1.25 (VBAT), U$2.1 (3V3), U$8.3 (VCC), U$9.28 (VDD)
5V: CH0.VCC, CH1.VCC, CH2.VCC, GPIO4.VCC, GPIO5.VCC, GPIO6.VCC, GPIO12.VCC, GPIO13.VCC, GPIO16.VCC, I2C0.VCC, I2C1.VCC, I2C2.VCC, PWM0.VCC, PWM1.VCC, PWM2.VCC, PWM3.VCC, R8.7 (2), R8.8 (2), R9.2, SJ1.1, SJ3.3, SJ4.1, U$2.2 (5V)
CE0: IC3.10 (CS), U$2.24 (CE0)
CH0: CH0.I/O, R4.1
CH1: CH1.I/O, R10.1
CH2: CH2.I/O, R14.1
CRX: JETSON.CAN_RX, U$8.4 (R)
CTX: JETSON.CAN_TX, U$8.1 (D)
GND: C1.1, C2.1, C3.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, CAN.GND, CH0.GND, CH1.GND, CH2.GND, GPIO4.GND, GPIO5.GND, GPIO6.GND, GPIO12.GND, GPIO13.GND, GPIO16.GND, I2C0.GND, I2C1.GND, I2C2.GND, IC1.1 (GND), IC2.11 (GND), IC3.9 (DGND), IC3.14 (AGND), JETSON.GND, PWM0.GND, PWM1.GND, PWM2.GND, PWM3.GND, R1.1, R1.2 (1), R1.3 (1), R1.4 (1), R2.1, R2.2 (1), R2.3 (1), R2.4 (1), R5.1, R11.1, R12.1, R13.1, R17.1, R18.2, SERIAL.GND, U1.2 (VLSS), U1.6 (D7), U1.7 (D6), U1.8 (D5), U1.9 (D4), U1.10 (D3), U1.14 (E/RD#), U1.15 (R/W#), U1.16 (D/C#), U1.18 (CS#), U1.19 (BS2), U1.21 (BS0), U1.23 (VSS), U$2.9 (GND), U$2.14 (GND), U$2.20 (GND), U$2.25 (GND), U$2.30 (GND), U$2.34 (GND), U$2.39 (GND), U$8.2 (GND), U$9.14 (VSS)
GPIO4: IC2.1 (A1), U$2.7 (GPIO4)
GPIO5: IC2.3 (A2), U$2.29 (GPIO5)
GPIO6: IC2.4 (A3), U$2.31 (GPIO6)
GPIO12: IC2.5 (A4), U$2.32 (GPIO12)
GPIO13: IC2.6 (A5), U$2.33 (GPIO13)
GPIO16: IC2.7 (A6), U$2.36 (GPIO16)
GPIO17: U$2.11 (GPIO17)
GPIO18: U$2.12 (GPIO18)
GPIO19: U$2.35 (GPIO19)
GPIO20: U$2.38 (GPIO20)
GPIO21: U$2.40 (GPIO21)
GPIO22: U$2.15 (GPIO22)
GPIO23: U$2.16 (GPIO23)
GPIO24: U$2.18 (GPIO24)
GPIO25: U$2.22 (GPIO25)
GPIO26: U$2.37 (GPIO26)
GPIO27: U$2.13 (GPIO27)
H_SCL: I2C0.SCL, I2C1.SCL, I2C2.SCL, IC1.6 (SCL2), R8.1
H_SDA: I2C0.SDA, I2C1.SDA, I2C2.SDA, IC1.5 (SDA2), R8.2 (1)
MISO: IC3.12 (DOUT), U$2.21 (MISO)
MOSI: IC3.11 (DIN), U$2.19 (MOSI)
unnamed: R3.1, U$9.6 (LED0)
unnamed: R3.2 (1), U$9.7 (LED1)
unnamed: R1.7 (2), U$9.1 (A0)
unnamed: R3.3 (1), U$9.8 (LED2)
unnamed: R3.4 (1), U$9.9 (LED3)
unnamed: R2.6 (2), U$9.23 (OE)
unnamed: R1.8 (2), U$9.25 (EXTCLK)
unnamed: GPIO4.I/O, IC2.20 (B1)
unnamed: R1.6 (2), U$9.2 (A1)
unnamed: R1.5 (2), U$9.3 (A2)
unnamed: R2.8 (2), U$9.4 (A3)
unnamed: R2.7 (2), U$9.5 (A4)
unnamed: C5.2, U1.27 (C1P)
unnamed: GPIO5.I/O, IC2.18 (B2)
unnamed: C5.1, U1.26 (C1N)
unnamed: GPIO6.I/O, IC2.17 (B3)
unnamed: GPIO12.I/O, IC2.16 (B4)
unnamed: C4.1, U1.28 (C2N)
unnamed: GPIO13.I/O, IC2.15 (B5)
unnamed: C4.2, U1.29 (C2P)
unnamed: GPIO16.I/O, IC2.14 (B6)
unnamed: R5.2, U1.5 (IREF)
unnamed: C1.2, U1.4 (VCOMH)
unnamed: C2.2, U1.3 (VCC)
unnamed: R6.1, U1.17 (RES#), U1.20 (BS1)
unnamed: C3.2, D1.ANODE, R6.2, R7.1
unnamed: IC2.10 (OE), R13.2, R16.1
unnamed: C11.2, IC2.19 (VCCB), SJ3.2
unnamed: SERIAL.VCC, SJ1.2
unnamed: IC3.3 (CH2), R14.2, R17.2
unnamed: SJ2.2, U$9.24 (A5)
unnamed: IC1.7 (VREF2), IC1.8 (EN), R9.1
unnamed: IC3.1 (CH0), R4.2, R11.2
unnamed: R2.5 (2), SJ2.1
unnamed: IC3.2 (CH1), R10.2, R12.2
unnamed: C9.2, IC3.15 (VREF), IC3.16 (VDD), SJ4.2
unnamed: CAN.CAN_H, R15.2, U$8.7 (CANH)
unnamed: CAN.CAN_L, R15.1, U$8.6 (CANL)
unnamed: R18.1, U$8.8 (RS)
NC1: U$2.4 (5V)
NC2: U$2.6 (GND)
PWM0: PWM0.I/O, R3.8 (2)
PWM1: PWM1.I/O, R3.7 (2)
PWM2: PWM2.I/O, R3.6 (2)
PWM3: PWM3.I/O, R3.5 (2)
RX: SERIAL.RX, U$2.10 (RX)
SCL: IC1.3 (SCL1), R8.3 (1), U1.13 (D0), U$2.5 (SCL), U$9.26 (SCL)
SCLK: IC3.13 (CLK), U$2.23 (SCLK)
SDA: IC1.4 (SDA1), R8.4 (1), U1.11 (D2), U1.12 (D1), U$2.3 (SDA), U$9.27 (SDA)
TX: SERIAL.TX, U$2.8 (TX)

Notes on the sheet:
1.0.2
Jetson Nano
PWM Controller
Address 0x60
1N4148
PIN HEADER
OLED
I2C (4pin 2mm pitch) x2
I2C
LEVEL CONVERTER
AnalogINPUT
GPIO
PWM
A/D Converter
※シリアルブリックに電源が必要な時は、SJ1をつなげます。
※FaBo Brickとの間には、電圧は５Vの通信となります。
CAN

Board: 2 copper layers, 101.6 x 50.8 mm, 67 parts (9 on the bottom side), 67 nets.

Other parts of the board:
U$3, U$4, U$5, U$6: MARK_POINT_3MM

## EAGLE design 0524_joystick_serial/pcb/524_joystick_serial.brd

Parts:
J1: FABO_BRICK_SERIAL-B04B-PASK-1; FABO_BRICK_SERIAL_B04B-PASK-1
LOGO1: LOGO_FABO-M_BOTTOM; LOGO_FABO_M_BOTTOM
U$2: ARDUINO_MICRO
U$3: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
5V: J1.VCC, U$2.5V
GND: J1.GND, U$2.GND2
PWM0: U$2.A0
PWM1: U$2.A1
PWM2: U$2.A2
PWM3: U$2.A3
PWM4: U$2.A4
PWM5: U$2.A5
RX1: J1.TX, U$2.RX1
TX1: J1.RX, U$2.TX1

Notes on the sheet:
1.0.0

Board: 2 copper layers, 17.8 x 63.5 mm, 4 parts (0 on the bottom side), 4 nets.

## EAGLE design 0525_kaya/pcb/524_kaya.brd

Board: 2 copper layers, 53.3 x 13.4 mm, 3 parts (0 on the bottom side), 4 nets.

Parts:
I2C: FABO_BRICK_I2C_B04B-PASK-1
U$2: JETSON_NANO_NOBORDER; JETSON_NANO_NOBOARDER
U$14: LOGO_FABO_MS

Connections:
5V: I2C.VCC, U$2.2
GND: I2C.GND, U$2.9, U$2.14, U$2.20, U$2.25, U$2.30, U$2.34, U$2.39
SCL: I2C.SCL, U$2.5
SDA: I2C.SDA, U$2.3

## EAGLE design 0526_outin_pico/PCB/526_AI_BLOCKS_Rev100.brd

Parts:
ANALOG: MODULAR-JACK-6P-RJ11_ANALOG3; 7002-6PXC-X
D1: NRVS1MFL; SD-123F
F1: POLYSWITCH; 0603
GP2,GP3, GP4,GP5, GP6,GP7, GP8,GP9: MODULAR-JACK-6P-RJ11_GPIO; 7002-6PXC-X
I2C: MODULAR-JACK-6P-RJ11_I2C; 7002-6PXC-X
JP4, JP7: JUMPERS_JP2-2MM
LOGO1: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
LOGO2: LOGO_FABO-M; LOGO_FABO_M
S2: TACT-SWITCH-SMD_KMR2; KMR2
SERIA+: MODULAR-JACK-6P-RJ11_SERIAL_M; 7002-6PXC-X
SPI: MODULAR-JACK-6P-RJ11_SPI; 7002-6PXC-X
SWD: FABO-SWD-4PIN; FABO_BRICK_SWD_B04B-PASK-1_SILK
U1: RASPBERRY_PI_PICORASPBERRY_PI_PICO_2BY20TH; RASPBERRY_PI_PICO_HEADER_BOTH
U$4, U$5, U$6, U$7: BLOCK_4-1; 4-1BLOCK
X1, X2: TSW-104-07-G-S; TSW-104-XX-G-S

Connections:
3V3: JP4.3, JP7.1, SWD.VCC, U1.36 (3V3), X2.1
A0: ANALOG.5 (5:A0), U1.31 (GP26)
A1: ANALOG.6 (6:A1), U1.32 (GP27)
A2: ANALOG.4 (4:A2), U1.34 (GP28)
AGND: ANALOG.1 (1:GND), U1.33 (AGND)
D2: GP2,GP3.5 (5:PIN-A), U1.4 (GP2)
D3: GP2,GP3.6 (6:PIN-B), U1.5 (GP3)
D4: GP4,GP5.5 (5:PIN-A), U1.6 (GP4)
D5: GP4,GP5.6 (6:PIN-B), U1.7 (GP5)
D6: GP6,GP7.5 (5:PIN-A), U1.9 (GP6)
D7: GP6,GP7.6 (6:PIN-B), U1.10 (GP7)
GND: GP2,GP3.1 (1:GND), GP4,GP5.1 (1:GND), GP6,GP7.1 (1:GND), GP8,GP9.1 (1:GND), I2C.1 (1:GND), S2.3, S2.4, SERIA+.1 (1:GND), SPI.1 (1:GND), SWD.GND, U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.38 (GND), U1.42 (GND), X1.1
GP21: U1.27 (GP21), X1.4
GP22: U1.29 (GP22), X2.4
unnamed: D1.2 (CATHODE), JP4.1, JP7.3
unnamed: ANALOG.3 (3:VCC), JP7.2
unnamed: F1.1, U1.40 (VBUS)
unnamed: D1.1 (ANODE), F1.2
unnamed: GP2,GP3.3 (3:VCC), GP4,GP5.3 (3:VCC), GP6,GP7.3 (3:VCC), GP8,GP9.3 (3:VCC), I2C.3 (3:VCC), JP4.2, SERIA+.3 (3:VCC), SPI.3 (3:VCC)
PWM14: U1.19 (GP14)
PWM15: U1.20 (GP15)
PWM16: U1.21 (GP16)
PWM17: U1.22 (GP17)
RESET: S2.1, S2.2, U1.30 (RUN)
RX: U1.12 (GP9)
SCL: U1.2 (GP1)
SDA: U1.1 (GP0)
SWCLK: SWD.SWCLK, U1.41 (SWCLK)
SWDIO: SWD.SWDIO, U1.43 (SWDIO)
TX: U1.11 (GP8)

Notes on the sheet:
Rev1.0.0
RESET
SWD (4pin 2mm pitch) x1/
MICROPHONE

Board: 2 copper layers, 24 parts (1 on the bottom side), 22 nets, no tracks yet.

Other parts of the board:
U$19: LOGO_SILK_GND

Notices in the files:
parts and their libraries:
FaBo-Template: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
