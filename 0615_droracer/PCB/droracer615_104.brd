# Repository FaBoPlatform/FaBo

## EAGLE design 0615_droracer/PCB/droracer615_104.brd

Parts:
1, 2, 3: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
.: TC2030-IDC-NL
C1: 4.7uF; 0603
C2, C4, C5, C10, C11: 10uF; 0603
C3, C13, C14, C15, C16, C17, C18, C19, C23: 0.1uF; 0603
C6: 12@f; 0603
C7: 12pf; 0603
C8, C20: 1uF; 0603
C9, C21: 0.01uF; 0603
C12, C22: 2.2uF; 0603
CY1: CRYSTAL-ABS07; ABRACON-ABS07-32.768KHZ
D1, D2, D4: 1N4148WS; SOD-323
D3: CUS05F40
IC1: LP2985-33DBV; SOT-23-5
IC2: LP2985-50; SOT-23-5
L1: 10uH; 0603
LOGO3: LOGO_FABO-S; LOGO_FABO_S
MDBT1: MDBT50
MODE: LED-0603-NARROW; 0603-NARROW
PAIR: LED-0603-NARROW; 0603-NARROW
PWR: LED-0603-NARROW; 0603-NARROW
R1, R2: 0; 0603-NARROW
R3: 220; EXBV8V
R4, R5, R6, R7: 680; 0603-NARROW
R8, R9, R10, R11: 220; 0603-NARROW
R12, R13: 100; 0603-NARROW
R14, R25: 1K; 0603-NARROW
R15, R21, R22: 4.7K; 0603-NARROW
R16, R17: 22; 0603-NARROW
R18, R19, R20, R23, R24: 10K; 0603-NARROW
R26, R27: 470; 0603-NARROW
SPI-LED: FABO-SPI-LED; SPI-B04B-PASK-1_2
ST: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
TH: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
TP1, TP2, TP3: TPB0,65; B0,65
U7: TLP291A; 11-3C1
U$1, U$13: CUS05F40
U$2: PCA9685
U$3: MULTIPLEXERSMC74HC157A; TSSOP-16
U$5, U$17: SWICTH-4P(KMR2); SWITCH-4P(KMR2)
U$8, U$14, U$18: SN74LVC1G17; SOT-23
U$10: PRTR5V0U2X; SOT-143B
U$11, U$12: 150R/1A; RESC0603_M
U$15, U$16: TLP2270
U$19: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
VM_CN1: USB-ZX62D; ZX62D-B-5PA8

Connections:
3V3: ..1 (VCC), C2.2, C11.2, C12.2, C13.1, C14.1, C16.2, IC1.5 (VOUT), L1.1, MDBT1.28 (VDD), MDBT1.30 (VDDH), MODE.ANODE, PAIR.ANODE, R21.2, R22.2, R23.2, TP3.TP, U7.4 (COL), U$2.28 (VDD), U$3.16 (VCC), U$13.A (ANODE), U$16.8 (8:VDD_)
5V: C1.2, C3.2, C4.2, PWR.ANODE, SPI-LED.VCC, U$10.4 (4:VCC), U$11.1, VM_CN1.1 (VBUS)
A0: R1.2, R16.2, R19.1, U$3.2 (A0)
A1: R2.2, R17.2, R20.1, U$3.5 (A1)
D4: MDBT1.8 (P1.15), R15.2, U7.3 (EMI)
D+: MDBT1.35 (D+), U$10.3 (3:INPUT/OUTPUT2), VM_CN1.3 (D+)
D-: MDBT1.34 (D-), U$10.2 (2:INPUT/OUTPUT1), VM_CN1.2 (D-)
GND: 1.GND, 2.GND, 3.GND, C15.2, C18.1, C19.1, C20.2, C21.2, C22.2, C23.2, IC2.2 (GND), R9.1, R11.1, R13.1, ST.GND, TH.GND, U$8.3 (GND), U$14.3 (GND), U$15.5 (5:GND), U$18.3 (GND)
GND2: ..6 (SWO), C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.2, C14.2, C16.1, C17.1, IC1.2 (GND), MDBT1.1 (GND), MDBT1.2 (GND), MDBT1.15 (GND), MDBT1.33 (GND), MDBT1.55 (GND), R5.1, R7.1, R15.1, R18.2, R19.2, R20.2, R24.1, R25.1, SPI-LED.GND, U$2.1 (A0), U$2.2 (A1), U$2.3 (A2), U$2.4 (A3), U$2.5 (A4), U$2.14 (VSS), U$2.23 (OE), U$2.24 (A5), U$2.25 (EXTCLK), U$3.8 (GND), U$5.3, U$5.4, U$10.1 (1:GND), U$12.1, U$16.5 (5:GND), U$17.3
MISO: MDBT1.25 (P1.08)
MOSI: MDBT1.61 (P1.01), SPI-LED.DI
unnamed: R3.2 (1), U$2.6 (LED0)
unnamed: R3.1, U$2.7 (LED1)
unnamed: U$12.2, VM_CN1.5 (GND), VM_CN1.B1 (GND), VM_CN1.B2 (GND), VM_CN1.B3 (GND), VM_CN1.B4 (GND), VM_CN1.T1 (GND), VM_CN1.T2 (GND), VM_CN1.T3 (GND), VM_CN1.T4 (GND), VM_CN1.T5 (GND), VM_CN1.T6 (GND)
unnamed: R4.2, U$15.1 (1:AN1)
unnamed: C9.2, IC1.4 (BYPASS)
unnamed: C15.1, U$1.C (CATHODE), U$15.8 (8:VDD_)
unnamed: C5.2, C8.2, C10.2, IC1.1 (VIN), IC1.3 (ON/OFF), MDBT1.32 (VBUS), U$11.2, U$13.C (CATHODE)
unnamed: R4.1, U$3.4 (Y0)
unnamed: D4.C, U$8.2 (A)
unnamed: 3.I/O, D4.A
unnamed: R12.1, U$8.4 (Y)
unnamed: R6.1, U$3.7 (Y1)
unnamed: MDBT1.4 (P1.11), R24.2, U$3.15 (EN)
unnamed: R5.2, U$15.2 (2:CA1)
unnamed: R6.2, U$15.3 (3:CA2)
unnamed: R7.2, U$15.4 (4:AN2)
unnamed: C7.2, CY1.P$2, MDBT1.17 (P0.00/XL1)
unnamed: C6.2, CY1.P$1, MDBT1.18 (P0.01/XL2)
unnamed: L1.2, MDBT1.31 (DCCH)
unnamed: R8.2, U$16.1 (1:AN1)
unnamed: R9.2, U$16.2 (2:CA1)
unnamed: R10.2, U$16.3 (3:CA2)
unnamed: R11.2, U$16.4 (4:AN2)
unnamed: D1.C, U$18.2 (A)
unnamed: R10.1, U$14.4 (Y)
unnamed: R8.1, U$18.4 (Y)
unnamed: R12.2, R14.2, U7.1 (A)
unnamed: R13.2, R14.1, U7.2 (C)
unnamed: R16.1, U$16.7 (7:OUT1)
unnamed: R17.1, U$16.6 (6:OUT2)
unnamed: MDBT1.21 (P0.05/AIN3), R1.1
unnamed: MDBT1.7 (P1.14), R18.1, U$3.1 (SEL)
unnamed: PWR.CATHODE, R25.2
unnamed: R3.7 (2), U$3.3 (B0)
unnamed: R3.8 (2), U$3.6 (B1)
unnamed: PAIR.CATHODE, R26.2
unnamed: MDBT1.3 (P1.10), R26.1
unnamed: MODE.CATHODE, R27.2
unnamed: MDBT1.41 (P0.17), U$17.2
unnamed: MDBT1.43 (P0.21), R27.1
unnamed: MDBT1.23 (P0.07), R2.1
unnamed: 1.I/O, D1.A
unnamed: 2.I/O, D2.A
unnamed: D2.C, U$14.2 (A)
unnamed: C21.1, IC2.4 (BYPASS)
unnamed: C20.1, D3.C (CATHODE), IC2.1 (VIN), IC2.3 (ON/OFF)
unnamed: C18.2, C19.2, C22.1, C23.1, IC2.5 (VOUT), U$8.5 (VCC), U$14.5 (VCC), U$18.5 (VCC)
P0.06: MDBT1.22 (P0.06)
P0.09: ..5 (GND), MDBT1.52 (P0.09/NFC1)
P0.11: ..3 (NRESET), MDBT1.27 (P0.11)
P0.16: MDBT1.38 (P0.16)
P0.24: MDBT1.48 (P0.24)
P1.02: MDBT1.50 (P1.02)
P1.09: MDBT1.26 (P1.09)
PDMCLK: MDBT1.19 (P0.26)
PDMDIN: MDBT1.49 (P0.25)
RCH1: ST.I/O, U$15.7 (7:OUT1)
RCH2: TH.I/O, U$15.6 (6:OUT2)
RESET: C17.2, MDBT1.40 (P0.18/RESET), R23.1, U$5.2
SCK: MDBT1.37 (P0.13), SPI-LED.CI
SCL: MDBT1.11 (P0.02/AIN0), R22.1, TP2.TP, U$2.26 (SCL)
SDA: MDBT1.12 (P0.31/AIN7), R21.1, TP1.TP, U$2.27 (SDA)
SWCLK: ..4 (SWCLK), MDBT1.53 (SWDCLK)
SWDIO: ..2 (SWDIO), MDBT1.51 (SWDIO)
VIN: 1.VCC, 2.VCC, 3.VCC, D3.A (ANODE), ST.VCC, TH.VCC, U$1.A (ANODE)

Notes on the sheet:
PWM Controller
Address 0x40
MULTIPLEXERS
PIN HEADER
LED-SPI
USB
RESET
BLE Module
Debug/Programming
P0_09 RX, P0_11 TX
Raytac
MDBT50
サーボ、ESCに接続
受信機に接続
PRTR5V0U2X
MAF1608GAD601CT000
LP2985-33
74HC157A
ペアリングインジケーター(Bule)
RC_BAT_POWER
MOBILE_BAT_POWER
SIGNAL OUTPUT ENABLE/DISNABLE(GREEN）
SIGNAL OUTPUT
SPI送信のみ
PROPO
Red
SN74LVC1G17
1.0.4

Board: 2 copper layers, 69.0 x 27.7 mm, 91 parts (12 on the bottom side), 68 nets.

Other parts of the board:
U$4: MARK_POINT_3MM

## EAGLE design 0616_spo2/pcb/616_spo2.brd

Parts:
.: TC2030-IDC-NL
C3: 0.1uF; 0603
C4, C12: 22u; 0805-R2013X50N
C6: 12@f; 0603
C7: 12pf; 0603
C10, C11: 10uF; 0603
CY1: CRYSTAL-ABS07; ABRACON-ABS07-32.768KHZ
D2: PMEG6020; SODFL3517X110N
IC4: MPM3610
L1: 10uH; 0603
LOGO1: LOGO_FABO-M; LOGO_FABO_M
MDBT1: MDBT50
R4: 100K; 0603
R5: 39K; 0603
R7: 75K; 0603
R11: 24K; 0603
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
U$5: SWICTH-4P(KMR2); SWITCH-4P(KMR2)
VM_CN1: USB-ZX62D; ZX62D-B-5PA8

Connections:
3V3: ..1 (VCC), C3.2, C4.1, C11.2, IC4.7 (OUT), IC4.8 (OUT), IC4.9 (OUT), IC4.20 (OUT), L1.1, MDBT1.28 (VDD), MDBT1.30 (VDDH), R7.2
5V: C10.2, D2.A, MDBT1.32 (VBUS), VM_CN1.1 (VBUS); also elsewhere on the board
A0: MDBT1.20 (P0.04/AIN2)
A1: MDBT1.21 (P0.05/AIN3)
A2: MDBT1.14 (P0.30/AIN6)
A3: MDBT1.10 (P0.29/AIN5)
D4: MDBT1.8 (P1.15)
D+: MDBT1.35 (D+), VM_CN1.3 (D+)
D-: MDBT1.34 (D-), VM_CN1.2 (D-)
FB: IC4.1 (FB), R7.1, R11.2
GND: ..6 (SWO), C3.1, C4.2, C6.1, C7.1, C10.1, C11.1, C12.2, IC4.3 (AGND), IC4.12 (GND), IC4.13 (GND), IC4.14 (GND), MDBT1.1 (GND), MDBT1.2 (GND), MDBT1.15 (GND), MDBT1.33 (GND), MDBT1.55 (GND), R5.1, R11.1, U$5.3, VM_CN1.5 (GND), VM_CN1.B1 (GND), VM_CN1.B2 (GND), VM_CN1.B3 (GND), VM_CN1.B4 (GND), VM_CN1.T1 (GND), VM_CN1.T2 (GND), VM_CN1.T3 (GND), VM_CN1.T4 (GND), VM_CN1.T5 (GND), VM_CN1.T6 (GND); also elsewhere on the board
MISO: MDBT1.25 (P1.08)
MOSI: MDBT1.61 (P1.01)
unnamed: IC4.17 (EN), R4.1
unnamed: C12.1, D2.C, IC4.16 (VIN), R4.2
unnamed: IC4.18 (AAM), R5.2
unnamed: C7.2, CY1.P$2, MDBT1.17 (P0.00/XL1)
unnamed: C6.2, CY1.P$1, MDBT1.18 (P0.01/XL2)
unnamed: L1.2, MDBT1.31 (DCCH)
P0.06: MDBT1.22 (P0.06)
P0.09: ..5 (GND), MDBT1.52 (P0.09/NFC1)
P0.11: ..3 (NRESET), MDBT1.27 (P0.11)
P0.16: MDBT1.38 (P0.16)
P0.24: MDBT1.48 (P0.24)
P1.02: MDBT1.50 (P1.02)
P1.09: MDBT1.26 (P1.09)
PDMCLK: MDBT1.19 (P0.26)
PDMDIN: MDBT1.49 (P0.25)
RESET: MDBT1.40 (P0.18/RESET), U$5.2
SCK: MDBT1.37 (P0.13)
SCL_HV: MDBT1.11 (P0.02/AIN0); also elsewhere on the board
SDA_HV: MDBT1.12 (P0.31/AIN7); also elsewhere on the board
SWCLK: ..4 (SWCLK), MDBT1.53 (SWDCLK)
SWDIO: ..2 (SWDIO), MDBT1.51 (SWDIO)

Notes on the sheet:
BETA
Regulator
USB
Push Button
BLE Module
Debug
P0_09 RX, P0_11 TX

Parts:
C1: 1uF; 0603
C5: 0.1uF; 0603
C8: 4.7uF; 0603
C9: 10uF; 0603
IC1: PCA9306GM; XQFN8
IC2: LP2985-33DBV; SOT-23-5
MAX30100: MA-MAX30100; MAXIM-30100
R6: 200k; 0603
R8, R9: 4.7k; 0603
TP1, TP2: TP-15

Connections:
1V8: C1.2, C8.2, IC1.2 (VREF1), IC2.5 (VOUT), MAX30100.11 (VDD), R8.2, R9.2
5V: C9.2, IC2.1 (VIN), IC2.3 (ON/OFF), MAX30100.9 (R_LED+), MAX30100.10 (IR_LED+), R6.2; also elsewhere on the board
GND: C1.1, C5.1, C8.1, C9.1, IC1.1 (GND), IC2.2 (GND), MAX30100.4 (PGND), MAX30100.12 (GND); also elsewhere on the board
unnamed: C5.2, IC1.7 (VREF2), IC1.8 (EN), R6.1
SCL: IC1.3 (SCL1), MAX30100.2 (SCL), R8.1, TP2.1
SCL_HV: IC1.6 (SCL2); also elsewhere on the board
SDA: IC1.4 (SDA1), MAX30100.3 (SDA), R9.1, TP1.1
SDA_HV: IC1.5 (SDA2); also elsewhere on the board

Notes on the sheet:
1.0.0.Beta

Board: 2 copper layers, 33 parts (0 on the bottom side), 23 nets, no tracks yet.

## EAGLE design 0617_jetracer_mini/PCB/617_jetracer_mini.brd

Parts:
C2: 0.1uF; 0603
I2C1: FABO_BRICK_I2C-S04B-PASK-2; FABO_BRICK_I2C_S04B-PASK-2
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1, R4: 10k; EXBV8V
R3: 220; EXBV8V
ST: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
TH: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
U$2: JETSON_NANO_NOBORDER; JETSON_NANO_NOBOARDER
U$3: PCA9685
U$5: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
3V3: C2.2, U$2.1 (3V3), U$3.28 (VDD)
5V: I2C1.VCC, U$2.2 (5V)
CE0: U$2.24 (CE0)
GND: C2.1, I2C1.GND, R1.1, R1.2 (1), R1.3 (1), R1.4 (1), R4.1, R4.2 (1), R4.3 (1), R4.4 (1), ST.GND, TH.GND, U$2.6 (GND), U$2.9 (GND), U$2.14 (GND), U$2.20 (GND), U$2.25 (GND), U$2.30 (GND), U$2.34 (GND), U$2.39 (GND), U$3.14 (VSS)
GPIO4: U$2.7 (GPIO4)
GPIO5: U$2.29 (GPIO5)
GPIO6: U$2.31 (GPIO6)
GPIO12: U$2.32 (GPIO12)
GPIO13: U$2.33 (GPIO13)
GPIO16: U$2.36 (GPIO16)
GPIO17: U$2.11 (GPIO17)
GPIO18: U$2.12 (GPIO18)
GPIO19: U$2.35 (GPIO19)
GPIO20: U$2.38 (GPIO20)
GPIO21: U$2.40 (GPIO21)
GPIO22: U$2.15 (GPIO22)
GPIO23: U$2.16 (GPIO23)
GPIO24: U$2.18 (GPIO24)
GPIO25: U$2.22 (GPIO25)
GPIO26: U$2.37 (GPIO26)
GPIO27: U$2.13 (GPIO27)
MISO: U$2.21 (MISO)
MOSI: U$2.19 (MOSI)
unnamed: R3.1, U$3.6 (LED0)
unnamed: R3.2 (1), U$3.7 (LED1)
unnamed: R4.5 (2), U$3.23 (OE)
unnamed: R1.8 (2), U$3.25 (EXTCLK)
unnamed: R1.7 (2), U$3.1 (A0)
unnamed: R1.6 (2), U$3.2 (A1)
unnamed: R1.5 (2), U$3.3 (A2)
unnamed: R4.8 (2), U$3.4 (A3)
unnamed: R4.7 (2), U$3.5 (A4)
unnamed: R4.6 (2), U$3.24 (A5)
PWM0: R3.8 (2), ST.I/O
PWM1: R3.7 (2), TH.I/O
RX: U$2.10 (RX)
SCL: I2C1.SCL, U$2.5 (SCL), U$3.26 (SCL)
SCLK: U$2.23 (SCLK)
SDA: I2C1.SDA, U$2.3 (SDA), U$3.27 (SDA)
TX: U$2.8 (TX)
VCC: ST.VCC, TH.VCC

Notes on the sheet:
1.0.0
Jetson Nano
PWM Controller
Address 0x60
PIN HEADER
ICSP
I2C

Board: 2 copper layers, 77.5 x 18.3 mm, 13 parts (0 on the bottom side), 18 nets.

Other parts of the board:
U$4, U$6: MARK_POINT_3MM

Notices in the files:
parts and their libraries:
FaBo-Template: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
