# Repository FaBoPlatform/FaBo

## EAGLE design 0111_microphone/pcb/124_micamp.brd

Parts:
C1: 2.2uF; 0603
C2, C8: 0.1uF; 0603
C3: 3300pF; 0603
C4: 1uF; 0603
C5, C7: 0.01uF; 0603
C6: 10uF; C1206K
C9, C11: 1uF; C2012
C10, C12: 4.7uF; C2012
IC2: LP2985-33; SOT-23-5
JMP1, JMP2: 0R-JUMPA; A0R-JMP
MIC: FABO_BRICK_3PIN-S03B-PASK-2; FABO_BRICK_3PIN_S03B-PASK-2
OP1: OPA344; SOT23-5
OUT: FABO_BRICK_3PIN-S03B-PASK-2; FABO_BRICK_3PIN_S03B-PASK-2
R1: 100K; 0603
R2, R3: 47K; 0603
R4: 500; 0603
R7: 1K; 0603
R10: DNP; 0603
R11: 0; 0603
SJ1: SJ
U$3, U$4: RSX101VA-30
U$5: TPS60241(VSSOP8); VSSOP8

Connections:
5V: C12.1, JMP1.3, U$5.1 (VOUT)
33V: C1.2, IC2.5 (VOUT), JMP1.1
GND: C1.1, C3.1, C4.1, C6.2, C7.1, C8.1, C10.2, C12.2, IC2.2 (GND), MIC.GND, OP1.2 (V-), OUT.GND, R2.1, R10.1, U$3.A (ANODE), U$4.A (ANODE), U$5.4 (GND)
unnamed: OP1.3 (+), R11.2, U$3.K (CATHODE)
unnamed: C2.1, MIC.I/O
unnamed: C5.2, OP1.4 (-), R1.1, R7.2
unnamed: C6.1, R7.1
unnamed: C5.1, OP1.1 (OUT), R1.2, R4.1
unnamed: C7.2, IC2.4 (BYPASS)
unnamed: C2.2, R2.2, R3.1, R11.1
unnamed: C3.2, OUT.I/O, R4.2, R10.2, U$4.K (CATHODE)
unnamed: C9.1, U$5.3 (C2-)
unnamed: C9.2, U$5.5 (C1-)
unnamed: C11.1, U$5.8 (C2+)
unnamed: C11.2, U$5.7 (C1+)
unnamed: C10.1, JMP2.1, U$5.2 (EN), U$5.6 (VIN)
unnamed: C4.2, IC2.1 (VIN), IC2.3 (ON/OFF), JMP2.3
VCC: JMP2.2, OUT.VCC, SJ1.1
VCC_ON: C8.2, JMP1.2, MIC.VCC, OP1.5 (V+), R3.2, SJ1.2

Notes on the sheet:
LP2985-33
Direct power source
VOLTAGE SELECT 1
VOLTAGE SELECT 2
3.3V~5V
1.0.1 A
CONNECT MICROPHONE

Board: 2 copper layers, 33.1 x 15.5 mm, 30 parts (9 on the bottom side), 19 nets.

Other parts of the board:
U$2: LOGO_FABO_S

## EAGLE design 0112_ir_led/PCB/112_ir_led.brd

Parts:
IR: LED-5MM; LED_5MM
J1: FABO_BRICK_3PIN
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1: 220; AXL-REGULAR
U$3: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
GND: J1.GND, R1.1
unnamed: IR.A (ANODE), J1.I/O
unnamed: IR.K (CATHODE), R1.2

Notes on the sheet:
1.0.5

Board: 2 copper layers, 25.4 x 33.0 mm, 5 parts (0 on the bottom side), 3 nets.

## EAGLE design 0113_ir_receive/PCB/113_ir_receive.brd

Parts:
J1: FABO_BRICK_3PIN
LOGO1: LOGO_FABO-M; LOGO_FABO_M
Q1: L-51ROPT1D1; LED-5MM
Q2: NPN-2SC1815; TO-92
R1, R2: 1k; AXL-REGULAR
U$6: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
GND: J1.GND, R2.1
INPUT: J1.I/O, Q2.1 (E), R2.2
unnamed: Q1.K (C), R1.1
unnamed: Q2.3 (B), R1.2
VCC: J1.VCC, Q1.A (E), Q2.2 (C)

Notes on the sheet:
1.0.6

Board: 2 copper layers, 25.4 x 33.0 mm, 7 parts (0 on the bottom side), 5 nets.

## EAGLE design 0114_uv/PCB/114_uv.brd

Parts:
C1: 0.01uF; 0603-NARROW
C2: 10uF; 0603-NARROW
C3: 0.1uF; 0603-NARROW
C4: 100pF; 0603-NARROW
C5: NC; 0603-NARROW
J1: PA-3; FABO_BRICK_3PIN
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1: 10M; 0603
R2: 0; 0603
R3, R4: 1G; 0603
R5: 1M; 0603
S1: SLIDE-SSSS810701; SSSS810701
U1: G6262; GAASP-G6262
U$2: OPENLOGO; LOGO_OSHW_M_BOTTOM
U$4: MCP6491; SOT-23

Connections:
GND: C2.2, C3.2, C4.1, C5.1, J1.GND, R4.2, U1.3 (A), U$4.2 (S), U$4.3 (+)
unnamed: C1.1, C4.2, R1.2, R3.1, R5.2, U1.2 (K), U$4.4 (-)
unnamed: C5.2, J1.I/O, R2.1
unnamed: R3.2, R4.1
unnamed: C1.2, R2.2, S1.2, U$4.1 (O)
unnamed: R5.1, S1.3
unnamed: R1.1, S1.1
VCC: C2.1, C3.1, J1.VCC, U$4.5 (V)

Notes on the sheet:
1.0.7
VOUT = ID * R1 or R5
※実装の際は、熱を過剰に与えないこと
RF1
RF2

Board: 2 copper layers, 25.4 x 33.0 mm, 16 parts (5 on the bottom side), 8 nets.

## EAGLE design 0114_uv/PCB/114_uv_1_0_4.brd

Parts:
C1: 0.01uF; 0603-NARROW
C2: 10uF; 0603-NARROW
C3: 0.1uF; 0603-NARROW
C4: NC; 0603-NARROW
C5: 100pF; 0603-NARROW
J1: PA-3; FABO_BRICK_3PIN
R1: 10M; 0603
R2: 4.7K; 0603
R3: 2000M; 0603
U1: G6262; GAASP-G6262
U$2: OPENLOGO; LOGO_OSHW_M_BOTTOM
U$3: FaBo Made in Japan; LOGO_FABO_MS
U$4: MCP6491; SOT-23

Connections:
GND: C2.2, C3.2, C4.2, C5.1, J1.GND, R3.2, U1.2 (A), U$4.2 (S), U$4.3 (+)
unnamed: C1.1, C5.2, R1.2, R3.1, U1.3 (K), U$4.4 (-)
unnamed: C4.1, J1.I/O, R2.1
unnamed: C1.2, R1.1, R2.2, U$4.1 (O)
VCC: C2.1, C3.1, J1.VCC, U$4.5 (V)

Notes on the sheet:
1.0.4
VOUT = ID * R1

Board: 2 copper layers, 25.4 x 33.0 mm, 13 parts (0 on the bottom side), 5 nets.

## EAGLE design 0115_humidity/PCB/115_humidity.brd

Parts:
J1: FABO_BRICK_3PIN
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1: 10k; AXL-REGULAR
U1: DHT11
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
GND: J1.GND, U1.4 (GND)
unnamed: J1.I/O, R1.2, U1.2 (I/O)
unnamed: J1.VCC, R1.1, U1.1 (VCC)

Notes on the sheet:
1.0.5

Board: 2 copper layers, 25.4 x 33.0 mm, 5 parts (0 on the bottom side), 3 nets.

## EAGLE design 0117_slideswitch/PCB/117_slideswitch.brd

Parts:
J1: FABO_BRICK_3PIN
LOGO1: LOGO_FABO-M; LOGO_FABO_M
SW1: SLIDE; EG1218
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
GND: J1.GND, SW1.1
IO: J1.I/O, SW1.2
VCC: J1.VCC, SW1.3

Notes on the sheet:
1.0.1

Board: 2 copper layers, 25.4 x 33.0 mm, 4 parts (0 on the bottom side), 3 nets.

## EAGLE design 0118_hall/PCB/118_hall.brd

Parts:
A3144: A3144; SOT-89
J1: FABO_BRICK_3PIN
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1: 1K; 0603
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
GND: A3144.2 (GND), J1.GND
IO: A3144.3 (OUTPUT), J1.I/O, R1.1
VCC: A3144.1 (VCC), J1.VCC, R1.2

Notes on the sheet:
1.0.1

Board: 2 copper layers, 25.4 x 33.0 mm, 5 parts (0 on the bottom side), 3 nets.

Notices in the files:
parts and their libraries:
FaBo-Capacitor: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
