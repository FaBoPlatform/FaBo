# Repository FaBoPlatform/FaBo

## EAGLE design 0241_Current_Measurement/pcb/0241_Current_Measurement.brd

Parts:
C1: 2.2uF; 0603
C2: 0.1uF/50V; 0603
C10: 1uF; 0603
C14: 0.01uF; 0603
C15: 0.1uF; 0603
D2: 1N4148; 1N4148W
IC1: LP2985-33; SOT-23-5
J1: FABO_BRICK_I2C-S04B-PASK-2; FABO_BRICK_I2C_S04B-PASK-2
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1, R2: 10; 0603
R3, R6: NC; 0603
R4, R5: 10K; 0603
SHUNT1: WSL2512; 2512INCH
SJ1: SJ2W; SJ_2
TP1, TP5: TP-15
U$1: TI-INA219
U$5: 2606-1102/020-000
U$6, U$7: FABO-SMD-JUMPER-SELECT-NARROW; SMD-JUMPER_SELECT_NARROW
U$8: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
3V3: C1.2, IC1.5 (VOUT), SJ1.1, TP5.1, U$6.1, U$7.1
5V: D2.ANODE, J1.VCC, SJ1.3
GND: C1.1, C10.1, C14.1, C15.1, IC1.2 (GND), J1.GND, R4.1, R5.1, TP1.1, U$1.6 (GND)
unnamed: R5.2, U$1.1 (A1), U$7.2
unnamed: R4.2, U$1.2 (A0), U$6.2
unnamed: C15.2, R3.2, R6.2, SJ1.2, U$1.5 (VS)
unnamed: C2.2, R1.2, U$1.8 (IN+)
unnamed: C2.1, R2.2, U$1.7 (IN-)
unnamed: C10.2, D2.CATHODE, IC1.1 (VIN), IC1.3 (ON/OFF)
unnamed: C14.2, IC1.4 (BYPASS)
SCL: J1.SCL, R3.1, U$1.4 (SCL)
SDA: J1.SDA, R6.1, U$1.3 (SDA)
VI+: R1.1, SHUNT1.P$1 (1), U$5.P$2 (R)
VI-: R2.1, SHUNT1.P$2 (2), U$5.P$3 (L)

Notes on the sheet:
1.0.1
0.1Ω 1%
どちらかに半田すること デフォルト １−２ すべてつながないこと
LP2985-33
高調波フィルタリング が必要な場合はR1,R2 10orm,ひつがない時は0orm,C2は0.1uFを実装のこと

Board: 2 copper layers, 46.0 x 46.0 mm, 26 parts (0 on the bottom side), 14 nets.

Other parts of the board:
U$3, U$4: MARK_POINT_3MM

## EAGLE design 0242_arrayrelay_gpio/pcb/242_arrayrelay.brd

Parts:
1, 2, 3: FABO_BRICK_3PIN-S03B-PASK-2; FABO_BRICK_3PIN_S03B-PASK-2
CN1: PIN_HEADER_1X2; PIN_1X2
JP2: JP1E; JP1
LOGO1: LOGO_FABO-M; LOGO_FABO_M
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
+5V: CN1.2, JP2.2; also elsewhere on the board
GND: 1.GND, 2.GND, 3.GND, CN1.1; also elsewhere on the board
GPIO0: 1.I/O; also elsewhere on the board
GPIO1: 2.I/O; also elsewhere on the board
GPIO2: 3.I/O; also elsewhere on the board
VCC: 1.VCC, 2.VCC, 3.VCC, JP2.1; also elsewhere on the board

Notes on the sheet:
1.0.0
※VCCが5V以外の場合はつないではいけません。
RELAY1
RELAY2
RELAY3
INPUT

Parts:
COM1: TBL004-508
LED1: LED-0402-NO_SILK; 0402-NO_SILK
M1: MOSFET-N_FDN335N; SUPERSOT-3
NC1: TBL004-508
R1, R3, R4: 1K; 0603-NARROW
R2: 10K; 0603-NARROW
RL1: G2RL-1
U4: TLP291A; 11-3C1
U$3: NRVS1MFL; SD-123F
U$7: TBL004-508

Connections:
+5V: RL1.1, U4.4 (COL), U$3.2 (CATHODE); also elsewhere on the board
GND: M1.S, R2.1, R3.1; also elsewhere on the board
GPIO0: LED1.CATHODE; also elsewhere on the board
unnamed: M1.D, RL1.5, U$3.1 (ANODE)
unnamed: R1.1, R3.2, U4.3 (EMI)
unnamed: M1.G, R1.2, R2.2
unnamed: LED1.ANODE, U4.2 (C)
unnamed: R4.2, U4.1 (A)
unnamed: NC1.P$1, NC1.P$2, RL1.2
unnamed: COM1.P$1, COM1.P$2, RL1.4
unnamed: RL1.3, U$7.P$1, U$7.P$2
VCC: R4.1; also elsewhere on the board

Notes on the sheet:
1.0.0
COM
G2RL-1
FDN335N
GPIO0
RELAY1
NRVS1MFL

Parts:
COM2: TBL004-508
LED2: LED-0402-NO_SILK; 0402-NO_SILK
M2: MOSFET-N_FDN335N; SUPERSOT-3
NC2: TBL004-508
R5, R7, R8: 1K; 0603-NARROW
R6: 10K; 0603-NARROW
RL2: G2RL-1
U1: TLP291A; 11-3C1
U$6: NRVS1MFL; SD-123F
U$9: TBL004-508

Connections:
+5V: RL2.1, U1.4 (COL), U$6.2 (CATHODE); also elsewhere on the board
GND: M2.S, R6.1, R7.1; also elsewhere on the board
GPIO1: LED2.CATHODE; also elsewhere on the board
unnamed: M2.D, RL2.5, U$6.1 (ANODE)
unnamed: R5.1, R7.2, U1.3 (EMI)
unnamed: M2.G, R5.2, R6.2
unnamed: NC2.P$1, NC2.P$2, RL2.2
unnamed: COM2.P$1, COM2.P$2, RL2.4
unnamed: RL2.3, U$9.P$1, U$9.P$2
unnamed: LED2.ANODE, U1.2 (C)
unnamed: R8.2, U1.1 (A)
VCC: R8.1; also elsewhere on the board

Notes on the sheet:
1.1.0
COM
G2RL-1
FDN335N
GPIO1
RELAY2
NRVS1MFL

Parts:
COM3: TBL004-508
LED3: LED-0402-NO_SILK; 0402-NO_SILK
M3: MOSFET-N_FDN335N; SUPERSOT-3
NC3: TBL004-508
R10, R12, R13: 1K; 0603-NARROW
R11: 10K; 0603-NARROW
RL3: G2RL-1
U2: TLP291A; 11-3C1
U$11: NRVS1MFL; SD-123F
U$12: TBL004-508

Connections:
+5V: RL3.1, U2.4 (COL), U$11.2 (CATHODE); also elsewhere on the board
GND: M3.S, R11.1, R12.1; also elsewhere on the board
GPIO2: LED3.CATHODE; also elsewhere on the board
unnamed: M3.D, RL3.5, U$11.1 (ANODE)
unnamed: R10.1, R12.2, U2.3 (EMI)
unnamed: M3.G, R10.2, R11.2
unnamed: NC3.P$1, NC3.P$2, RL3.2
unnamed: COM3.P$1, COM3.P$2, RL3.4
unnamed: RL3.3, U$12.P$1, U$12.P$2
unnamed: LED3.ANODE, U2.2 (C)
unnamed: R13.2, U2.1 (A)
VCC: R13.1; also elsewhere on the board

Notes on the sheet:
1.1.0
COM
G2RL-1
FDN335N
GPIO2
RELAY3
NRVS1MFL

Board: 2 copper layers, 75.0 x 48.0 mm, 43 parts (21 on the bottom side), 30 nets.

## EAGLE design 0243_imu/pcb/0243_imu.brd

Parts:
C1, C3, C4: 0.1uF; EIA0603
C2: 1uF; EIA0603
IC1: BMI160
IC2: LP2985-33DBV; SOT-23-5
IC3: PCA9306GM; XQFN8
J1: FABO_BRICK_I2C
JP1: JUMPER-2_SMD; JUMPER-SMD-2
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1, R2: 4.7k; EIA0603
R3: 200k; EIA0603
R4: 10k; EIA0603
TP1, TP2, TP3, TP4: TP-15
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
3V3: C2.2, C3.2, C4.2, IC1.5 (VDDIO), IC1.8 (VDD), IC1.12 (CSB), IC2.5 (VOUT), IC3.2 (VREF1), JP1.1, R1.2, R2.2
5V: IC2.1 (VIN), IC2.3 (ON/OFF), J1.VCC, R3.2
ADDRESS: IC1.1 (SDO), JP1.2, R4.2
GND: C1.1, C2.1, C3.1, C4.1, IC1.6 (GNDIO), IC1.7 (GND), IC2.2 (GND), IC3.1 (GND), J1.GND, R4.1
INT1: IC1.4 (INT1), TP3.1
INT2: IC1.9 (INT2), TP4.1
PCAVREF: C1.2, IC3.7 (VREF2), IC3.8 (EN), R3.1
SCL: IC1.13 (SCX), IC3.3 (SCL1), R1.1, TP2.1
SCL_HV: IC3.6 (SCL2), J1.SCL
SDA: IC1.14 (SDX), IC3.4 (SDA1), R2.1, TP1.1
SDA_HV: IC3.5 (SDA2), J1.SDA

Notes on the sheet:
BETA
I2C address Default: 0x68 JP1 short: 0x69

Board: 2 copper layers, 27.9 x 39.4 mm, 19 parts (5 on the bottom side), 11 nets.

## EAGLE design 0245_gas detection/pcb/245_gas detection.brd

Board: 2 copper layers, 27.9 x 39.4 mm, 29 parts (12 on the bottom side), 15 nets.

Parts:
B1: BOSCH-BME680
C1, C8: 4.7uF; 0603
C2: 0.1uF; 0603
C3, C7: 0.01uF; 0603
C4, C9: 1uF; 0603
C5, C6: 100nf; 0603
D1, D2: CUS05F40
IC1, IC2: SOT-23-5
IC3: 8PIN-SSOP
J1: FABO_BRICK_I2C
LOGO1: LOGO_FABO_M
R1, R2: 4.7k; 0603
R3: 200k; 0603
R4: 10k; 0603
SJ1: SJ
SJ2: SJ_2
TP1, TP2, TP3, TP4, TP5: TP-15
U$2: LOGO_OSHW_M_BOTTOM

Connections:
1V8: B1.2, B1.6, B1.8, C1.2, C5.2, C6.2, IC2.5, IC3.2, R1.2, R2.2, R4.2, TP3.1
3V3: C8.2, IC1.5, SJ2.3, TP5.1
5V: D1.A, D2.A, J1.VCC, SJ2.1
GND: B1.1, B1.7, C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, IC1.2, IC2.2, IC3.1, J1.GND, SJ1.1, TP4.1
unnamed: C2.2, IC3.7, IC3.8, R3.1
unnamed: B1.5, R4.1, SJ1.2
unnamed: C3.2, IC2.4
unnamed: C4.2, D1.C, IC2.1, IC2.3
unnamed: R3.2, SJ2.2
unnamed: C7.2, IC1.4
unnamed: C9.2, D2.C, IC1.1, IC1.3
SCL: B1.4, IC3.3, R1.1, TP2.1
SCL_HV: IC3.6, J1.SCL
SDA: B1.3, IC3.4, R2.1, TP1.1
SDA_HV: IC3.5, J1.SDA

Notices in the files:
parts and their libraries:
FaBo-Capacitor: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
