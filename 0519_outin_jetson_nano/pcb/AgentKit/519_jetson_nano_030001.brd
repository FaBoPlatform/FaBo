# Repository FaBoPlatform/FaBo

## EAGLE design 0519_outin_jetson_nano/pcb/AgentKit/519_jetson_nano_030001.brd

Schematic: 519_jetson_nano_030001.sch

Parts:
A1: CAPACITOR-OS-CON; F13
C1, C2, C3, C4, C5: 0.1uF; 0603-NARROW
C6, C7, C13, C14, C15, C19: 0.1uF; 0603
C8: 10uF; 0603
C9, C20: 15pF; 0603
C10: 1uF; 0603
C11, C12, C18: 4.7uF; 0603
C16: DNP; 0603
C17: 4.7uF 1KV; 0603
CN1, CN2, CN3, CN4, CN5: PIN_1X1-SMALL; PIN_1X1_SMALL
CN6: PIN-HEADER-SMT(1.27MM)2X5
D1, D24: PMEG6020AELR; SOD123W
FB1, FB2: FERRITEBEADS; 0603
GPIO5,6,1, GPIO5,6,2, GPIO5,6,22: MODULAR-JACK-6P-RJ11_GPIO3; 7002-6PXC-X
I2C, I2C1: MODULAR-JACK-6P-RJ11_I2C; 7002-6PXC-X
I2S0(DAP4)1: MODULAR-JACK-6P-RJ11_I2S_MASTER; 7002-6PXC-X
IC1: PCA9306_SSOP; 8PIN-SSOP
IC2: PCA9685BSPCA9685BS; HVQFN28
L1, L2: MAF1608F; 1608MM
LED0, LED1, LED2, LED3, LED4: WS2812B_NARROW
LED5, LED10, LED11, LED12: LED-0603; 0603
LED6, LED13, LED14: IR; LED_5MM
LED7, LED8, LED9: LED-5MM; LED_5MM
M1: MOSFET-N_FDN335N; SUPERSOT-3
R1, R9, R10, R40: 0; 0603
R2, R3, R38, R39, R41, R42: DNP; 0603
R4, R5, R8, R11, R12: 510(1/4W); R0805
R6: 634K; 0603
R7: 220; EXBV8V
R13: 220; 0603
R14: 10K; 0603
R15, R16, R19, R20, R24, R25, R28, R29, R30, R31, R36, R37: 5.1K; 0603
R17, R18: 100K; 0603
R21: 1K; 0603
R22, R23: DFN; 0603
R26: 100K1%; 0603
R27: 13.7K1%; 0603
R32, R33, R34: 330; 0603
R35: 200K; 0603
SPI2-0, SPI2-1: MODULAR-JACK-6P-RJ11_SPI; 7002-6PXC-X
ST, ST1: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
SW1: TACT-SWITCH-SMD_KMR2; KMR2
T3, T4: TBL004-508
U$11, U$12: AVRF060X100LT242; AVRF0X0X100LT_0603
U$13: MAX98357A,B; TQFN(16L3*3*0.75)
U$14: 2MMJUMPER_CROSS; PINHEAD2MM_CROSS
U$18: JETSON_NANOJETSON_NANO_OVERALL; JETSON_NANO_DEMENTION
U$19: R7FA4M1AB3CFM; LQFP-64_RENESAS
U$21: CSTNE16M0V53L00ZR0; 3-SMD
U$22: 5077CR-16-SMC2-BK-TR
U$23: PRTR5V0U2X; SOT143B
U$25: PMEG2010ER; SOD123W
U$28: 74LVC1G125; TSOP5(SOT753)
UART2: MODULAR-JACK-6P-RJ11_SERIAL_M_USART; 7002-6PXC-X

Connections:
3DB: R17.2, U$14.2
3V3: C15.2, IC2.25:VDD (VDD), R8.2
5V: C12.2, C13.2, C14.2, C19.2, CN6.1, D1.1 (CATHODE), D24.1 (CATHODE), FB2.1, LED11.ANODE, LED12.ANODE, R4.2, R5.2, R11.2, R12.2, R15.2, R16.1, R19.1, R20.1, R26.1, R28.1, SPI2-0.3 (3:VCC), SPI2-1.3 (3:VCC), U$19.4:VBATT, U$19.11:VCC, U$19.21:VCC_USB_LDO, U$19.39:VCC, UART2.3 (3:VCC)
15DB: R18.1, U$14.4
AREF: FB1.1, R15.1
CAN0_RX: U$19.46:P102
CAN0_TX: U$19.45:P103
DAC: U$19.53:P014
G1: GPIO5,6,1.5 (5:PIN-A), R10.2
G2: GPIO5,6,2.5 (5:PIN-A), R40.2
G6: GPIO5,6,22.5 (5:PIN-A), R1.2
GAIN: U$13.2 (2:GAIN), U$14.1
GND: A1.CATHODE (-), C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, CN1.1, CN2.1, CN6.3, CN6.5, CN6.9, GPIO5,6,1.1 (1:GND), GPIO5,6,2.1 (1:GND), GPIO5,6,22.1 (1:GND), I2C.1 (1:GND), I2C1.1 (1:GND), I2S0(DAP4)1.1 (1:GND), IC1.1 (GND), IC2.1:A3 (A3), IC2.2:A4 (A4), IC2.11:VSS (VSS), IC2.20:OE (OE), IC2.21:A5 (A5), IC2.22:EXTCLK (EXTCLK), IC2.26:A0 (A0), IC2.27:A1 (A1), IC2.28:A2 (A2), IC2.29 (VSS), LED0.3-VSS (VSS), LED1.3-VSS (VSS), LED2.3-VSS (VSS), LED3.3-VSS (VSS), LED4.3-VSS (VSS), LED5.CATHODE, M1.S, R2.2, R8.1, R14.2, R18.2, R25.2, R27.2, R29.2, R30.2, R31.2, R32.2, R38.2, R41.2, SPI2-0.1 (1:GND), SPI2-1.1 (1:GND), ST.GND, ST1.GND, SW1.3, SW1.4, U$11.2, U$12.2, U$13.3 (3:GND), U$13.11 (11:GND), U$13.15 (15:GND), U$13.17 (EP), U$14.5, U$18.9 (GND), U$18.14 (GND), U$18.20 (GND), U$18.25 (GND), U$18.30 (GND), U$18.34 (GND), U$18.39 (GND), U$19.8:VSS, U$19.17:VSS_USB, U$19.40:VSS, U$19.57:AVSS0, U$21.2:GND (2), U$22.A1,B12:GND (GND), U$22.B1,A12:GND (GND), U$28.1 (1:OE), U$28.3 (3:GND), UART2.1 (1:GND)
GPIO2/SDA1: I2C.5 (5:SDA), I2C1.5 (5:SDA), IC1.4 (SDA1), IC2.24:SDA (SDA), R23.1, U$18.3 (SDA)
GPIO3/SCL1: I2C.4 (4:SCL), I2C1.4 (4:SCL), IC1.3 (SCL1), IC2.23:SCL (SCL), R22.1, U$18.5 (SCL)
GPIO4/AUDIO_MCLK: U$18.7 (GPIO4)
GPIO5/CAM_AF_EN: U$18.29 (GPIO5)
GPIO6: R1.1, R2.1, R3.2, R10.1, R38.1, R40.1, R41.1
GPIO6/GPIO_PZ0: U$18.31 (GPIO6)
GPIO7/SPI1_CS1: U$18.26 (CE1)
GPIO8/SPI1_CS0: U$18.24 (CE0)
GPIO9/SPI1_MISO: U$18.21 (MISO)
GPIO10/SPI1_MOSI: U$18.19 (MOSI), U$28.2 (2:A)
GPIO11/SPI1_SCLK: U$18.23 (SCLK)
GPIO12/LCD_BL_PWM: U$18.32 (GPIO12)
GPIO13/GPIO_PE6: U$18.33 (GPIO13)
GPIO14/TXD: U$18.8 (TX), UART2.5 (5:TX)
GPIO15/RXD: U$18.10 (RX), UART2.6 (6:RX)
GPIO16/UART2_CTS: U$18.36 (GPIO16), UART2.2 (2:CTS)
GPIO17/UART2_RTS: U$18.11 (GPIO17), UART2.4 (4:RTS)
GPIO18/I2S0_SCLK: I2S0(DAP4)1.4 (4:I2S_SCLK), U$13.16 (16:BLCK), U$18.12 (GPIO18)
GPIO19/I2S0_FS: I2S0(DAP4)1.2 (2:I2S_FS), U$13.14 (14:LRCLK), U$18.35 (GPIO19)
GPIO20/I2S0_DIN: I2S0(DAP4)1.5 (5:I2S_DIN), U$18.38 (GPIO20)
GPIO21/I2S0_DOUT: U$13.1 (1:DIN), U$18.40 (GPIO21)
GPIO22/LCD_TE: U$18.15 (GPIO22)
GPIO23/SPI2_CS1: SPI2-1.5 (5:CS), U$18.16 (GPIO23)
GPIO24/SPI2_CS0: SPI2-0.5 (5:CS), U$18.18 (GPIO24)
GPIO25/SPI2_MISO: SPI2-0.4 (4:MISO), SPI2-1.4 (4:MISO), U$18.22 (GPIO25)
GPIO26/SPI2_MOSI: SPI2-0.6 (6:MOSI), SPI2-1.6 (6:MOSI), U$18.37 (GPIO26)
GPIO27/SPI2_SCK: SPI2-0.2 (2:SCK), SPI2-1.2 (2:SCK), U$18.13 (GPIO27)
I2C0_SCL: U$18.28 (ID_SC)
I2C0_SDA: U$18.27 (ID_SD)
JETSON3V3: IC1.2 (VREF1), R3.1, R6.1, R17.1, R22.2, R23.2, R39.1, R42.1, U$14.3, U$18.1 (3V3), U$18.17 (3V3)
JETSON 5V: A1.ANODE (+), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, CN3.1, D1.2 (ANODE), GPIO5,6,1.3 (3:VCC), GPIO5,6,2.3 (3:VCC), GPIO5,6,22.3 (3:VCC), I2C.3 (3:VCC), I2C1.3 (3:VCC), I2S0(DAP4)1.3 (3:VCC), LED0.1-VDD (VDD), LED1.1-VDD (VDD), LED2.1-VDD (VDD), LED3.1-VDD (VDD), LED4.1-VDD (VDD), R21.2, R35.1, R36.1, R37.1, U$13.7 (7:VDD), U$13.8 (8:VDD), U$18.2 (5V), U$25.2 (ANODE), U$28.5 (5:VCC)
MONO: R6.2, U$13.4 (4:SD_MODE)
unnamed: LED0.2-DOUT (DOUT), LED1.4-DIN (DIN)
unnamed: LED6.A (ANODE), R4.1
unnamed: LED8.A (ANODE), R11.1
unnamed: LED9.A (ANODE), R12.1
unnamed: LED5.ANODE, R21.1
unnamed: LED1.2-DOUT (DOUT), LED2.4-DIN (DIN)
unnamed: IC2.4:LED1 (LED1), R7.1
unnamed: LED2.2-DOUT (DOUT), LED3.4-DIN (DIN)
unnamed: LED3.2-DOUT (DOUT), LED4.4-DIN (DIN)
unnamed: IC2.3:LED0 (LED0), R7.2 (1)
unnamed: LED6.K (CATHODE), LED7.K (CATHODE), LED8.K (CATHODE), LED9.K (CATHODE), M1.D
unnamed: R7.7 (2), ST.I/O
unnamed: R7.8 (2), ST1.I/O
unnamed: M1.G, R13.2, R14.1
unnamed: R13.1, U$19.42:P106
unnamed: LED7.A (ANODE), R5.1
unnamed: R9.2, U$28.4 (4:Y)
unnamed: C9.2, U$19.9:P213/XTAL, U$21.1:INPUT (1)
unnamed: C10.2, FB1.2, U$19.59:P010/VREFH0
unnamed: C7.2, FB2.2, U$19.56:AVCC0
unnamed: C20.2, U$19.10:P212/EXTAL, U$21.3:OUTPUT (3)
unnamed: C11.2, U$19.5:VCL
unnamed: R16.2, U$19.27:P200
unnamed: R19.2, U$19.26:P201/MD
unnamed: R24.2, R25.1
unnamed: R20.2, R24.1, U$19.16:P407
unnamed: ST.VCC, ST1.VCC, U$25.1 (CATHODE)
unnamed: R26.2, R27.1, U$19.49:P500
unnamed: LED0.4-DIN (DIN), R9.1
unnamed: R30.1, U$22.B5:CC2 (CC2)
unnamed: R31.1, U$22.A5:CC1 (CC1)
unnamed: LED10.CATHODE, R32.1
unnamed: LED10.ANODE, U$19.36:P111
unnamed: R34.2, U$19.54:P013/VREFL
unnamed: R33.2, U$19.55:P012/VREFH
unnamed: LED11.CATHODE, R33.1
unnamed: LED12.CATHODE, R34.1
unnamed: IC1.7 (VREF2), IC1.8 (EN), R35.2
NC: CN6.6
NC1: U$18.4 (5V)
NC2: U$18.6 (GND)
OUTN: L2.1, U$13.10 (10:OUTN)
OUTP: L1.1, U$13.9 (9:OUTP)
RA4_SCL_5V: IC1.6 (SCL2), R36.2, U$19.48:P100
RA4_SDA_5V: IC1.5 (SDA2), R37.2, U$19.47:P101
RESET: C16.2, CN6.10, R28.2, SW1.1, SW1.2, U$19.25:RES
SCII_RXD: CN6.7, U$19.51:P502
SCII_TXD: CN6.8, U$19.50:P501
SHILED: C17.2, R29.1, U$22.SHILED2, U$22.SHILED6 (SHILED2), U$23.1 (1:GND)
SP_MINUS: CN5.1, L2.2, T4.P$1, T4.P$2, U$12.1
SP_PLUS: CN4.1, L1.2, T3.P$1, T3.P$2, U$11.1
SWDCLK: CN6.4, U$19.32:P300/TCK/SWCLK (32:P300/SWCLK)
SWDIO: CN6.2, U$19.33:P108/TMS/SWDIO
USBLDO3V3: C18.2, U$19.20:VCC_USB
USB_DN: U$19.18:P915/USB_DM, U$22.A7:DN1 (DN1), U$22.B7:DN2 (DN2), U$23.2 (2:IO1)
USB_DP: U$19.19:P914/USB_DP, U$22.A6:DP1 (DP1), U$22.B6:DP2 (DP2), U$23.3 (3:IO2)
VBUS_5V2: D24.2 (ANODE), U$22.A4,B9:VBUS (VBUS), U$22.B4,A9:VBUS (VBUS), U$23.4 (4:VCC)

Notes on the sheet:
Revision
Jetson ORIN Nano 40Pin
Jetson Nano 40Pin Header
GPIO
Full Color SPI LED LEVEL SHIFT
初版 2022/07/11
1.2
I2C
I2C(2Port)
SERIAL
I2S INPUT(MIC)
I2S INTERNAL PCM Class D Amplifier(MONO)
1.0.2
AVRF060X100LT242
6dB
12dB
Open 9dB
MONO
lowPassFilter
NotchFilter,ESD Protection
SPEAKER TERMINAL
3dB
15dB
ServoControl
PCA9685BS
TEST PIN
5V INLET
INTERNAL
SUBMCU
USB
I2C LEVEL TRANSLATOR
Jetson Nano
RA4M1
0/ST
1/TH
OSCON 1000uF
SWD CONNECTOR
SPI(For LCD)
MAFF1608
SPI2

Board: 2 copper layers, 80.2 x 125.7 mm, 119 parts (2 on the bottom side), 84 nets, no tracks yet.

Other parts of the board:
U$17: LOGO_FABO_L

Notices in the files:
parts and their libraries:
FaBo-Resistors: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
FaBo-etc: Released under the Creative Commons
