# Repository FaBoPlatform/FaBo (continued)

## EAGLE design 0519_outin_jetson_nano/pcb/alpha/519_jetson_nano1016.brd

Parts:
A0, A1, A2, A3: FABO_BRICK_3PIN-B03B-PASK-1; FABO_BRICK_3PIN_B03B-PASK-1
C1, C2, C3, C20: 10uF; 0603
C4, C5, C6, C11, C15, C24: 1uF; 0603
C7, C8, C9, C12, C21: 0.1uF; 0603
C10, C13, C18: 0.1uF; 0402
C14: 20pF; 0402
C16, C23: 0.01uF; 0603
C17, C22: 4.7uF; 0603
C19: 0.1uF/0402; 0402
C100: 16SEPF1000M,1000uF/16V/Size_F13; F13
D1: 1N4148; 1N4148W
GPIO4, GPIO5, GPIO6, GPIO12, GPIO13, GPIO16, GPIO17, GPIO27: FABO_BRICK_3PIN-B03B-PASK-1; FABO_BRICK_3PIN_B03B-PASK-1
I2C0, I2C1, I2C2: FABO_BRICK_I2C-B04B-PASK-1; FABO_BRICK_I2C_B04B-PASK-1
I2S0, I2S1: FABO-I2S-7PIN; SPI-B07B-PASK-1
IC1: PCA9306_SSOP; 8PIN-SSOP
IC2, IC4: LP2985-33DBV; SOT-23-5
IC3: MICROCHIP-MCP3008
JP1, JP4: JUMPERS_JP2-2MM
JP2, JP6: JUMPER-SMT_2_NC_PASTE_SILK; SMT-JUMPER_2_NC_PASTE_SILK
JP3, JP5: JUMPER-SMT_3_1-NC_TRACE_SILK; SMT-JUMPER_3_1-NC_TRACE_SILK
LOGO1: LOGO_FABO-M; LOGO_FABO_M
PWM0, PWM1, PWM2, PWM3, PWM4, PWM5, PWM6, PWM7: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
R1, R2: 10k; EXBV8V
R3, R5: 220; EXBV8V
R4, R6, R11, R12, R13, R20: 4.7K; 0603
R7: 0; 0402
R8: 10K; EXBV8V
R9: 200K; 0603
R10, R14, R15, R16: 9.1K; 0603
R17, R23: 20K; 0603
R18, R28: 0; 0603
R19: 390K; 0603
R21, R24: 1M; 0603
R22: DNP; 0402
R25: 100; 0603
R26, R27: 10K; 0603
SERIAL: FABO_BRICK_SERIAL-B04B-PASK-1; FABO_BRICK_SERIAL_B04B-PASK-1
SJ2, SJ3, SJ5, SJ6: SMD-JUMPER-3-23SHORT; SMD-JUMPER-3
SPI1: FABO-SPI-7PIN; SPI-B07B-PASK-1
U1: ER-OLED0.96-1ER-CON30HT-1; ER-CON30HT-1
U2: TXB0108; R-PUSON-N20
U$2: JETSON_NANOJETSON_NANO_COMPA; JETSON_NANO_COMPA
U$7: TXB0102; VSSOP8
U$8: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
U$9: PCA9685
U$11: KC2016Z

Connections:
3.3V_A: C22.2, IC4.5 (VOUT), JP5.1
3V3: C6.2, C7.1, C8.2, C13.P$2 (2), C15.2, C18.P$1 (1), C20.1, C21.2, D1.CATHODE, IC1.2 (VREF1), IC3.16 (VDD), JP3.1, R7.P$2 (2), R8.5 (2), R8.6 (2), R17.2, R20.2, R23.2, R26.2, R27.2, SJ2.1, SJ3.1, SJ5.1, U1.22 (VDD), U1.25 (VBAT), U2.2 (VCCA), U$2.1 (3V3), U$7.3 (3:VCCA), U$9.28 (VDD), U$11.#4 (4:VCC)
5.0V_A: C17.2, IC2.5 (VOUT), JP5.3
5V: C10.P$2 (2), C11.2, C12.1, C24.2, C100.ANODE (+), GPIO4.VCC, GPIO5.VCC, GPIO6.VCC, GPIO12.VCC, GPIO13.VCC, GPIO16.VCC, GPIO17.VCC, GPIO27.VCC, I2C0.VCC, I2C1.VCC, I2C2.VCC, I2S0.2 (2:5V), I2S1.2 (2:5V), IC2.1 (VIN), IC2.3 (ON/OFF), IC4.1 (VIN), IC4.3 (ON/OFF), JP2.2, JP3.3, PWM0.VCC, PWM1.VCC, PWM2.VCC, PWM3.VCC, PWM4.VCC, PWM5.VCC, PWM6.VCC, PWM7.VCC, R8.7 (2), R8.8 (2), R9.2, SJ3.2, SJ3.3, SPI1.2 (2:5V), U2.19 (VCCB), U$2.2 (5V)
AGND: A0.GND, A1.GND, A2.GND, A3.GND, IC3.14 (AGND), R10.1, R14.1, R15.1, R16.1, R28.1
AVCC: A0.VCC, A1.VCC, A2.VCC, A3.VCC, C9.2, IC3.15 (VREF), JP5.2
CH0: A0.I/O, R4.1
CH1: A1.I/O, R11.1
CH2: A2.I/O, R12.1
CH3: A3.I/O, R13.1
GND: C1.1, C2.1, C3.1, C6.1, C7.2, C8.1, C9.1, C10.P$1 (1), C11.1, C12.2, C13.P$1 (1), C14.P$1 (1), C15.1, C16.1, C17.1, C18.P$2 (2), C19.P$1 (1), C20.2, C21.1, C22.1, C23.1, C24.1, C100.CATHODE (-), GPIO4.GND, GPIO5.GND, GPIO6.GND, GPIO12.GND, GPIO13.GND, GPIO16.GND, GPIO17.GND, GPIO27.GND, I2C0.GND, I2C1.GND, I2C2.GND, I2S0.1 (1:GND), I2S1.1 (1:GND), IC1.1 (GND), IC2.2 (GND), IC3.9 (DGND), IC4.2 (GND), PWM0.GND, PWM1.GND, PWM2.GND, PWM3.GND, PWM4.GND, PWM5.GND, PWM6.GND, PWM7.GND, R1.1, R1.2 (1), R1.3 (1), R1.4 (1), R2.1, R2.2 (1), R2.3 (1), R2.4 (1), R6.1, R19.1, R21.1, R22.P$1 (1), R24.1, R28.2, SERIAL.GND, SPI1.1 (1:GND), U1.2 (VLSS), U1.6 (D7), U1.7 (D6), U1.8 (D5), U1.9 (D4), U1.10 (D3), U1.14 (E/RD#), U1.15 (R/W#), U1.18 (CS#), U1.19 (BS2), U1.21 (BS0), U1.23 (VSS), U2.11 (GND), U$2.9 (GND), U$2.14 (GND), U$2.20 (GND), U$2.25 (GND), U$2.30 (GND), U$2.34 (GND), U$2.39 (GND), U$7.2 (2:GND), U$9.14 (VSS), U$11.#2 (2:CASE_GND)
GPIO4: JP1.2, U$2.7 (GPIO4)
GPIO5: U2.3 (A2), U$2.29 (GPIO5)
GPIO6: U2.4 (A3), U$2.31 (GPIO6)
GPIO12: U2.5 (A4), U$2.32 (GPIO12)
GPIO13: U2.6 (A5), U$2.33 (GPIO13)
GPIO16/UART1_CTS: U2.7 (A6), U$2.36 (GPIO16)
GPIO17/UART1_RTS: U2.9 (A8), U$2.11 (GPIO17)
GPIO22: JP6.2, U$2.15 (GPIO22)
GPIO23/SPI1_CS1: U$2.16 (GPIO23)
GPIO24/SPI1_CS0: SPI1.3 (3:CS), U$2.18 (GPIO24)
GPIO25/SPI1_MISO: SPI1.7 (7:MISO), U$2.22 (GPIO25)
GPIO26/SPI1_MOSI: SPI1.6 (6:MOSI), U$2.37 (GPIO26)
GPIO27: JP4.1, U2.8 (A7)
GPIO27/SPI1_SCK: JP4.2, U$2.13 (GPIO27)
H_SCL: I2C0.SCL, I2C1.SCL, I2C2.SCL, IC1.6 (SCL2), R8.2 (1)
H_SDA: I2C0.SDA, I2C1.SDA, I2C2.SDA, IC1.5 (SDA2), R8.1
I2C0_SCL: U$2.28 (ID_SC)
I2S0_DIN: I2S0.6 (6:DIN), I2S1.6 (6:DIN), U$2.38 (GPIO20)
I2S0_DOUT: I2S0.7 (7:DOUT), I2S1.7 (7:DOUT), U$2.40 (GPIO21)
I2S0_FS: I2S0.4 (4:LRCK), I2S1.4 (4:LRCK), U$2.35 (GPIO19)
I2S0_SCLK: I2S0.5 (5:BCLK), I2S1.5 (5:BCLK), U$2.12 (GPIO18)
MCLK: I2S0.3 (3:MCK), I2S1.3 (3:MCK), JP1.3
unnamed: R3.4 (1), U$9.6 (LED0)
unnamed: R1.6 (2), U$9.2 (A1)
unnamed: R3.2 (1), U$9.8 (LED2)
unnamed: R3.1, U$9.9 (LED3)
unnamed: JP6.1, R2.6 (2), U$9.23 (OE)
unnamed: C14.P$2 (2), R18.2, U$9.25 (EXTCLK), U$11.#3 (3:OUTPUT)
unnamed: GPIO4.I/O, U2.20 (B1)
unnamed: R1.5 (2), U$9.1 (A0)
unnamed: R1.7 (2), U$9.3 (A2)
unnamed: R2.8 (2), U$9.4 (A3)
unnamed: SERIAL.RX, U$7.1 (1:B2)
unnamed: C4.2, U1.27 (C1P)
unnamed: GPIO5.I/O, U2.18 (B2)
unnamed: C4.1, U1.26 (C1N)
unnamed: GPIO6.I/O, U2.17 (B3)
unnamed: GPIO12.I/O, U2.16 (B4)
unnamed: C5.1, U1.28 (C2N)
unnamed: GPIO13.I/O, U2.15 (B5)
unnamed: C5.2, U1.29 (C2P)
unnamed: GPIO16.I/O, U2.14 (B6)
unnamed: R19.2, U1.5 (IREF)
unnamed: C2.2, U1.4 (VCOMH)
unnamed: C1.2, U1.3 (VCC)
unnamed: R25.1, U1.17 (RES#)
unnamed: C3.2, D1.ANODE, R25.2, R26.1
unnamed: R23.1, R24.2, U2.10 (OE)
unnamed: GPIO27.I/O, U2.13 (B7)
unnamed: SERIAL.TX, U$7.8 (8:B1)
unnamed: IC3.3 (CH2), R12.2, R15.2
unnamed: JP1.1, U2.1 (A1)
unnamed: IC1.7 (VREF2), IC1.8 (EN), R9.1
unnamed: IC3.1 (CH0), R4.2, R10.2
unnamed: JP2.1, SERIAL.VCC
unnamed: IC3.2 (CH1), R11.2, R14.2
unnamed: C23.2, IC4.4 (BYPASS)
unnamed: IC3.4 (CH3), R13.2, R16.2
unnamed: PWM4.I/O, R5.5 (2)
unnamed: C16.2, IC2.4 (BYPASS)
unnamed: PWM5.I/O, R5.6 (2)
unnamed: R2.7 (2), SJ5.2, SJ5.3, U$9.5 (A4)
unnamed: R2.5 (2), SJ2.2, SJ2.3, U$9.24 (A5)
unnamed: R17.1, R21.2, U$7.6 (6:OE)
unnamed: R6.2, SJ6.2, SJ6.3, U1.16 (D/C#)
unnamed: R20.1, SJ6.1
unnamed: GPIO17.I/O, U2.12 (B8)
unnamed: PWM6.I/O, R5.7 (2)
unnamed: R7.P$1 (1), R22.P$2 (2), U$11.#1 (1:INH)
unnamed: PWM7.I/O, R5.8 (2)
unnamed: R1.8 (2), R18.1
unnamed: C19.P$2 (2), JP3.2, U$7.7 (7:VCCB)
unnamed: R5.4 (1), U$9.10 (LED4)
unnamed: R5.3 (1), U$9.11 (LED5)
unnamed: R5.2 (1), U$9.12 (LED6)
unnamed: R5.1, U$9.13 (LED7)
unnamed: R27.1, U1.20 (BS1)
unnamed: R3.3 (1), U$9.7 (LED1)
unnamed: PWM0.I/O, R3.5 (2)
NC1: U$2.4 (5V)
NC2: U$2.6 (GND)
PWM1: PWM1.I/O, R3.6 (2)
PWM2: PWM2.I/O, R3.7 (2)
PWM3: PWM3.I/O, R3.8 (2)
RX: U$2.10 (RX), U$7.4 (4:A2)
SCL: IC1.3 (SCL1), R8.3 (1), U1.13 (D0), U$2.5 (SCL), U$9.26 (SCL)
SDA: IC1.4 (SDA1), R8.4 (1), U1.11 (D2), U1.12 (D1), U$2.3 (SDA), U$9.27 (SDA)
SPI0_CS0: IC3.10 (CS), U$2.24 (CE0)
SPI0_CS1: U$2.26 (CE1)
SPI0_MISO: IC3.12 (DOUT), U$2.21 (MISO)
SPI0_MOSI: IC3.11 (DIN), U$2.19 (MOSI)
SPI0_SCLK: IC3.13 (CLK), U$2.23 (SCLK)
SPI1_SCLK: JP4.3, SPI1.5 (5:SCLK)
TX: U$2.8 (TX), U$7.5 (5:A1)

Notes on the sheet:
1.0.16
Jetson Nano 40Pin
PWM Controller
Address 0x40
1N4148
PIN HEADER
OLED
I2C
I2C LEVEL CONVERTER
AnalogINPUT
GPIO LEVELSHIFTER
PWM
A/D Converter
※シリアルブリックに電源が必要な時は、SJ2をつなげます。
PWM2
PWM0
SERIAL
I2S
※I2S信号は、3.3Vとなります。
Analog 5.0V
SPI1
※UARTは、信号レベルは5Vになります。
※アドレス設定
SPI
SPI_SCK
POWER OUTLET ONLY
※電源の入力はしないでください。(出力のみ)
1000uF
option
Analog 3V3
Revision
UART1_CTS
UART1_RTS
PWM OUTPUT

Notes on the sheet:
Rev13 5Vから3.3V LDOに変更 DCプラグ2.5mm
Rev14 2021/6/25 バリアショットキーダイオードの変更 入力電圧を5.9V DCプラグ変更 EIAJ2
Rev12 基板拡大、アダプタを追加、SPI、I2Sポート追加 5V LDOを追加 レベル変換UART追加

Board: 2 copper layers, 77.7 x 56.0 mm, 107 parts (67 on the bottom side), 100 nets.

Other parts of the board:
U$3, U$4, U$5, U$6: MARK_POINT_3MM
