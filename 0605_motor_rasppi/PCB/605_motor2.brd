# Repository FaBoPlatform/FaBo (continued)

## EAGLE design 0608_donkeycar/PCB/608_donkey_030000.brd

Parts:
C1: 10uF; 0603
C2, C3, C4, C5: 1uF; 0603-BOTTOM
C6, C7, C8: 10uF; 0603-BOTTOM
CON1: RASPBERRYPI_SHEILD; RASPBERRY_PI_SHILED
CON3: FABO_BRICK_I2C-S04B-PASK-2; FABO_BRICK_I2C_S04B-PASK-2
D1: 1N4148; 1N4148W
HC1, HC2, HC3, HC4, HC5, HC6, HC7, HC8: HC-SR04CONHS-SR04CON-SPEACING; HC-SR04CON-SPEACE
IC1: PCA9685BS; PCA9685
JP1: JUMPERS_JP2-2MM
LOGO1: LOGO_FABO-M; LOGO_FABO_M
PWM0: PWM0; PIN_1X3_NARROW
PWM1: PWM1; PIN_1X3_NARROW
R1, R2: 220; 0603
R3: DNP; 0603-BOTTOM
R4: 390K; 0603-BOTTOM
R5: 10K; 0603-BOTTOM
R6: 100; 0603-BOTTOM
R7, R9, R11, R13, R15, R17, R19, R21: 220 1%; 0603
R8, R10, R12, R14, R16, R18, R20, R22: 470 1%; 0603
U1: AE-BNO055-BO; DIP_8
U2: ER-OLED0.96-1ER-CON30HT-1_REV2; ER-CON30HT-1_REV2

Connections:
3V3: C1.2, C4.2, C5.2, CON1.1 (1:3V3_POWER), CON1.17 (17:3V3_POWER), D1.CATHODE, IC1.28 (VDD), JP1.3, R5.2, U1.1 (1:VIN), U1.1-1 (1:VIN), U2.22 (VDD), U2.25 (VBAT)
5V: CON1.2 (2:5V_POWER), CON3.VCC, JP1.1
BEC: PWM0.2 (VCC), PWM1.2 (VCC)
GND: C1.1, C4.1, C5.1, C6.1, C7.1, C8.1, CON1.9 (9:GND), CON1.14 (14:GND), CON1.20 (20:GND), CON1.25 (25:GND), CON1.30 (30:GND), CON1.34 (34:GND), CON1.39 (39:GND), CON3.GND, HC1.4 (4:GND), HC2.4 (4:GND), HC3.4 (4:GND), HC4.4 (4:GND), HC5.4 (4:GND), HC6.4 (4:GND), HC7.4 (4:GND), HC8.4 (4:GND), IC1.1 (A0), IC1.2 (A1), IC1.3 (A2), IC1.4 (A3), IC1.5 (A4), IC1.14 (VSS), IC1.23 (OE), IC1.24 (A5), IC1.25 (EXTCLK), PWM0.3 (GND), PWM1.3 (GND), R4.1, R8.1, R10.1, R12.1, R14.1, R16.1, R18.1, R20.1, R22.1, U1.2 (2:GND), U1.2-1 (2:GND), U1.7 (7:GND), U1.7-1 (7:GND), U2.2 (VLSS), U2.6 (D7), U2.7 (D6), U2.8 (D5), U2.9 (D4), U2.10 (D3), U2.14 (E/RD#), U2.15 (R/W#), U2.16 (D/C#), U2.18 (CS#), U2.19 (BS2), U2.21 (BS0), U2.23 (VSS)
INT: U1.6 (6:INT), U1.6-1 (6:INT)
LED0: IC1.6 (LED0), R1.2
LED1: IC1.7 (LED1), R2.2
unnamed: C2.1, U2.26 (C1N)
unnamed: C2.2, U2.27 (C1P)
unnamed: C3.1, U2.28 (C2N)
unnamed: C3.2, U2.29 (C2P)
unnamed: R4.2, U2.5 (IREF)
unnamed: C6.2, U2.4 (VCOMH)
unnamed: C7.2, U2.3 (VCC)
unnamed: R6.1, U2.17 (RES#), U2.20 (BS1)
unnamed: C8.2, D1.ANODE, R5.1, R6.2
NC1: CON1.4 (4:5V_POWER)
NC2: CON1.6 (6:GND)
PIN7: CON1.7 (7:GPIO4(GPCLK0)), R3.1
PIN11: CON1.11 (11:GPIO17(GPIO_GEN0)), R7.1, R8.2
PIN11_H: HC1.3 (3:ECHO), R7.2
PIN12: CON1.12 (12:GPIO18(GPIO_GEN1,PCM_CLK)), HC1.2 (2:TRIG)
PIN13: CON1.13 (13:GPIO27(GPIO_GEN2)), R9.1, R10.2
PIN13_H: HC2.3 (3:ECHO), R9.2
PIN15: CON1.15 (15:GPIO22(GPIO_GEN3)), R11.1, R12.2
PIN15_H: HC3.3 (3:ECHO), R11.2
PIN16: CON1.16 (16:GPIO23(GPIO_GEN4)), HC2.2 (2:TRIG)
PIN18: CON1.18 (18:GPIO24(GPIO_GEN5)), HC3.2 (2:TRIG)
PIN22: CON1.22 (22:GPIO25(GPIO_GEN6)), HC4.2 (2:TRIG)
PIN29: CON1.29 (29:GPIO5), R13.1, R14.2
PIN29_H: HC4.3 (3:ECHO), R13.2
PIN31: CON1.31 (31:GPIO6), R15.1, R16.2
PIN31_H: HC5.3 (3:ECHO), R15.2
PIN32: CON1.32 (32:GPIO12(PWM0)), HC5.2 (2:TRIG)
PIN33: CON1.33 (33:GPIO13(PWM1)), R17.1, R18.2
PIN33_H: HC6.3 (3:ECHO), R17.2
PIN35: CON1.35 (35:GPIO19(PCM_FS)), R19.1, R20.2
PIN35_H: HC7.3 (3:ECHO), R19.2
PIN36: CON1.36 (36:GPIO16), HC6.2 (2:TRIG)
PIN37: CON1.37 (37:GPIO26), R21.1, R22.2
PIN37_H: HC8.3 (3:ECHO), R21.2
PIN38: CON1.38 (38:GPIO20(PCM_DIN)), HC7.2 (2:TRIG)
PIN40: CON1.40 (40:GPIO21(PCM_DOUT)), HC8.2 (2:TRIG)
PWM0: PWM0.1 (I/O), R1.1
PWM1: PWM1.1 (I/O), R2.1
RESET: R3.2, U1.5 (5:RESET), U1.5-1 (5:RESET)
SCL: CON1.5 (5:GPIO3(I2C1_SCL)), CON3.SCL, IC1.26 (SCL), U1.4 (4:SCL/R), U1.4-1 (4:SCL/R), U2.13 (D0)
SDA: CON1.3 (3:GPIO2(I2C1_SDA)), CON3.SDA, IC1.27 (SDA), U1.3 (3:SDA/T), U1.3-1 (3:SDA/T), U2.11 (D2), U2.12 (D1)
TR_VCC: HC1.1 (1:VCC), HC2.1 (1:VCC), HC3.1 (1:VCC), HC4.1 (1:VCC), HC5.1 (1:VCC), HC6.1 (1:VCC), HC7.1 (1:VCC), HC8.1 (1:VCC), JP1.2
VOUT: U1.8 (8:VOUT), U1.8-1 (8:VOUT)

Notes on the sheet:
3.0.0
1N4148
RC Carへ接続
I2Cポート
OLED（青色）
PWM信号出力
超音波センサー接続 1~8 HC-SR04
慣性計測ユニット
シングルボードコンピュータGPIOピン
HC-SR04 VCC
DKTG-01G

Board: 2 copper layers, 65.0 x 56.5 mm, 49 parts (22 on the bottom side), 48 nets.

Other parts of the board:
U$3: LOGO_SILK_GND

Notices in the files:
parts and their libraries:
FaBo-Resistors: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
