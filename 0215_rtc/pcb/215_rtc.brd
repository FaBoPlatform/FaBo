# Repository FaBoPlatform/FaBo

## EAGLE design 0215_rtc/pcb/215_rtc.brd

Parts:
C1: 1uF; 0603
C2, C3: 0.1uF; 0603
IC1: RTC-PCF2129AT; SO20
IC2: LP2985-33DBV; SOT-23-5
IC3: PCA9306GM; XQFN8
J1: FABO_BRICK_I2C
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1, R2: 4.7k; 0603
R3: 200k; 0603
TP1, TP2, TP3, TP4, TP5: TP-15
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
U$4: BATTERY-SMTU2450; TAKACHI-SMTU2450

Connections:
3V3: C1.2, C3.2, IC1.20 (VDD), IC2.5 (VOUT), IC3.2 (VREF1), R1.2, R2.2
5V: IC2.1 (VIN), IC2.3 (ON/OFF), J1.VCC, R3.2
GND: C1.1, C2.1, C3.1, IC1.8 (VSS), IC2.2 (GND), IC3.1 (GND), J1.GND, U$4.2 (-)
unnamed: IC1.19 (VBAT), U$4.1 (+)
unnamed: C2.2, IC3.7 (VREF2), IC3.8 (EN), R3.1
unnamed: IC1.5 (IFS), IC1.18 (BBS)
unnamed: IC1.6 (TS), TP3.1
unnamed: IC1.7 (CLKOUT), TP4.1
unnamed: IC1.17 (INT), TP5.1
SCL: IC1.1 (SCL), IC3.3 (SCL1), R1.1, TP2.1
SCL_HV: IC3.6 (SCL2), J1.SCL
SDA: IC1.4 (SDA), IC3.4 (SDA1), R2.1, TP1.1
SDA_HV: IC3.5 (SDA2), J1.SDA

Notes on the sheet:
1.0.4
OPTIONAL

Board: 2 copper layers, 27.9 x 39.4 mm, 18 parts (6 on the bottom side), 13 nets.

## EAGLE design 0216_matrix/pcb/216_matrix.brd

Parts:
A0, A1, A2: JUMPER-3_SMD; JUMPER-SMD-3
C1: 0.1uF; EIA0603
IC1: PCA9532BS; HVQFN24
J1: FABO_BRICK_I2C
LOGO1: LOGO_FABO-S; LOGO_FABO_S
R1, R2: 4.7k; EIA0603
U1: MATRIX_8X8_A_COM; GYXM-788ASR
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
5V: A0.1, A1.1, A2.1, C1.1, IC1.21 (VDD), J1.VCC, R1.2, R2.2
A0: A0.2, IC1.22 (A0)
A1: A1.2, IC1.23 (A1)
A2: A2.2, IC1.24 (A2)
GND: A0.3, A1.3, A2.3, C1.2, IC1.9 (VSS), J1.GND
unnamed: IC1.1 (LED0), U1.13 (COL1)
unnamed: IC1.2 (LED1), U1.3 (COL2)
unnamed: IC1.3 (LED2), U1.4 (COL3)
unnamed: IC1.4 (LED3), U1.10 (COL4)
unnamed: IC1.5 (LED4), U1.6 (COL5)
unnamed: IC1.6 (LED5), U1.11 (COL6)
unnamed: IC1.7 (LED6), U1.15 (COL7)
unnamed: IC1.8 (LED7), U1.16 (COL8)
unnamed: IC1.10 (LED8), U1.9 (ROW1)
unnamed: IC1.11 (LED9), U1.14 (ROW2)
unnamed: IC1.12 (LED10), U1.8 (ROW3)
unnamed: IC1.13 (LED11), U1.12 (ROW4)
unnamed: IC1.14 (LED12), U1.1 (ROW5)
unnamed: IC1.15 (LED13), U1.7 (ROW6)
unnamed: IC1.16 (LED14), U1.2 (ROW7)
unnamed: IC1.17 (LED15), U1.5 (ROW8)
SCL: IC1.19 (SCL), J1.SCL, R2.1
SDA: IC1.20 (SDA), J1.SDA, R1.1

Notes on the sheet:
1.0.1
I2C ADDRESS SELECT
DEFAULT:LOW

Board: 2 copper layers, 27.9 x 39.4 mm, 11 parts (3 on the bottom side), 23 nets.

## EAGLE design 0218_hall/pcb/218_hall.brd

Parts:
A1334: A1335; LE-14
C1: 1uF; 0603
C2, C3, C4: 0.1uF; 0603
IC2: LP2985-33DBV; SOT-23-5
IC3: PCA9306GM; XQFN8
J1: FABO_BRICK_I2C
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1, R2: 4.7k; 0603
R3: 200k; 0603
TP1, TP2: TP-15
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
3V3: C1.2, IC2.5 (VOUT), IC3.2 (VREF1), R1.2, R2.2
5V: A1334.5 (VCC), C3.2, IC2.1 (VIN), IC2.3 (ON/OFF), J1.VCC, R3.2
GND: A1334.1 (DGND), A1334.3 (DGND), A1334.7 (AGND), A1334.8 (ISEL), A1334.12 (SA1), A1334.13 (SA0), A1334.14 (DGND), C1.1, C2.1, C3.1, C4.1, IC2.2 (GND), IC3.1 (GND), J1.GND
unnamed: A1334.2 (BYP), C4.2
unnamed: C2.2, IC3.7 (VREF2), IC3.8 (EN), R3.1
SCL: A1334.11 (SCL), IC3.3 (SCL1), R1.1, TP2.1
SCL_HV: IC3.6 (SCL2), J1.SCL
SDA: A1334.10 (SDA), IC3.4 (SDA1), R2.1, TP1.1
SDA_HV: IC3.5 (SDA2), J1.SDA

Notes on the sheet:
1.0.1

Board: 2 copper layers, 27.9 x 39.4 mm, 15 parts (2 on the bottom side), 9 nets.

## EAGLE design 0220_nfc/pcb/220_nfc.brd

Parts:
C1: 1uF; 0603
C2: 0.1uF; 0603
C7: 100nF; 0603
IC2: LP2985-33DBV; SOT-23-5
IC3: PCA9306GM; XQFN8
J1: FABO_BRICK_I2C
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1, R2: 4.7k; 0603
R3: 200k; 0603
TP1, TP2: TP-15
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
U$4: ST-ST25DV64K; SO-8
UF1: HIROSE-U.FL; HIROSE-UF.L

Connections:
3V3: C1.2, C7.2, IC2.5 (VOUT), IC3.2 (VREF1), R1.2, R2.2, U$4.8 (VCC)
5V: IC2.1 (VIN), IC2.3 (ON/OFF), J1.VCC, R3.2
ANTENA0: U$4.2 (AC0), UF1.GND@1 (GND), UF1.GND@2 (GND)
ANTENA1: U$4.3 (AC1), UF1.SIG
GND: C1.1, C2.1, C7.1, IC2.2 (GND), IC3.1 (GND), J1.GND, U$4.4 (VSS)
unnamed: C2.2, IC3.7 (VREF2), IC3.8 (EN), R3.1
SCL: IC3.3 (SCL1), R1.1, TP2.1, U$4.6 (SCL)
SCL_HV: IC3.6 (SCL2), J1.SCL
SDA: IC3.4 (SDA1), R2.1, TP1.1, U$4.5 (SDA)
SDA_HV: IC3.5 (SDA2), J1.SDA

Notes on the sheet:
1.0.1

Board: 2 copper layers, 27.9 x 39.4 mm, 15 parts (2 on the bottom side), 10 nets.

## EAGLE design 0221_pulse/pcb/221_pulse.brd

Parts:
C1: 1uF; 0603
C2: 0.1uF; 0603
C3: 4.7uF; 0603
C4: 10uF; 0603
IC2: LP2985-33DBV; SOT-23-5
IC3: PCA9306GM; XQFN8
J1: FABO_BRICK_I2C
LOGO1: LOGO_FABO-M; LOGO_FABO_M
MAX30100: MA-MAX30100; MAXIM-30100
R1, R2: 4.7k; 0603
R3: 200k; 0603
TP1, TP2: TP-15
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
1V8: C1.2, C3.2, IC2.5 (VOUT), IC3.2 (VREF1), MAX30100.11 (VDD), R1.2, R2.2
5V: C4.2, IC2.1 (VIN), IC2.3 (ON/OFF), J1.VCC, MAX30100.9 (R_LED+), MAX30100.10 (IR_LED+), R3.2
GND: C1.1, C2.1, C3.1, C4.1, IC2.2 (GND), IC3.1 (GND), J1.GND, MAX30100.4 (PGND), MAX30100.12 (GND)
unnamed: C2.2, IC3.7 (VREF2), IC3.8 (EN), R3.1
SCL: IC3.3 (SCL1), MAX30100.2 (SCL), R1.1, TP2.1
SCL_HV: IC3.6 (SCL2), J1.SCL
SDA: IC3.4 (SDA1), MAX30100.3 (SDA), R2.1, TP1.1
SDA_HV: IC3.5 (SDA2), J1.SDA

Notes on the sheet:
1.0.1

Board: 2 copper layers, 27.9 x 39.4 mm, 15 parts (2 on the bottom side), 8 nets.

## EAGLE design 0222_environment/pcb/222_environment.brd

Parts:
B1: BO-BME680; BOSCH-BME680
C1: 4.7uF; 0603
C2: 0.1uF; 0603
C3: 0.01uF; 0603
C4: 1uF; 0603
C5, C6: 100nf; 0603
D1: CUS05F40
IC2: LP2985-33DBV; SOT-23-5
IC3: PCA9306_SSOP; 8PIN-SSOP
J1: FABO_BRICK_I2C
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1, R2: 4.7k; 0603
R3: 200k; 0603
R4: 10k; 0603
SJ1: SJ
TP1, TP2, TP3, TP4: TP-15
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
1V8: B1.2 (CSB), B1.6 (VDDIO), B1.8 (VDD), C1.2, C5.2, C6.2, IC2.5 (VOUT), IC3.2 (VREF1), R1.2, R2.2, R4.2, TP3.1
5V: D1.A (ANODE), J1.VCC, R3.2
GND: B1.1 (GND), B1.7 (GND), C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, IC2.2 (GND), IC3.1 (GND), J1.GND, SJ1.1, TP4.1
unnamed: C2.2, IC3.7 (VREF2), IC3.8 (EN), R3.1
unnamed: B1.5 (SDO), R4.1, SJ1.2
unnamed: C3.2, IC2.4 (BYPASS)
unnamed: C4.2, D1.C (CATHODE), IC2.1 (VIN), IC2.3 (ON/OFF)
SCL: B1.4 (SCK), IC3.3 (SCL1), R1.1, TP2.1
SCL_HV: IC3.6 (SCL2), J1.SCL
SDA: B1.3 (SDI), IC3.4 (SDA1), R2.1, TP1.1
SDA_HV: IC3.5 (SDA2), J1.SDA

Notes on the sheet:
1.0.3
BME680
LP2985-18
1-2を半田すること（デフォルト）

Board: 2 copper layers, 27.9 x 39.4 mm, 22 parts (5 on the bottom side), 11 nets.

Notices in the files:
parts and their libraries:
FaBo-etc: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
