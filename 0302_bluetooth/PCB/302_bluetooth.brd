# Repository FaBoPlatform/FaBo

## EAGLE design 0302_bluetooth/PCB/302_bluetooth.brd

Parts:
C1, C4: 1uF; 0603
C3: 0.1uF; 0603
IC1: LP2985-33DBV; SOT-23-5
J1: FABO_BRICK_SERIAL
LED1: STAT; 0603-NARROW
LED2: CON; 0603-NARROW
LOGO1: LOGO_FABO-M_BOTTOM; LOGO_FABO_M_BOTTOM
Q1, Q2: BSS138; SOT23-3
R1, R2: 180; 0603-NARROW
R4, R5, R6, R7: 10k; 0603-NARROW
TP10, TP11: TP-15
U$1: MICROCHIP-RN42
U$4: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
3V3: C1.2, C3.2, C4.2, IC1.5 (VOUT), Q1.1 (G), Q2.1 (G), R4.2, R6.2, U$1.11 (VDD)
5V: IC1.1 (VIN), IC1.3 (ON/OFF), J1.VCC, R5.2, R7.2
GND: C1.1, C3.1, C4.1, IC1.2 (GND), J1.GND, LED1.CATHODE, LED2.CATHODE, U$1.1 (GND1), U$1.4 (GPIO7), U$1.12 (GND2), U$1.28 (GND3), U$1.29 (GND4)
unnamed: LED1.ANODE, R1.1
unnamed: R2.2, U$1.19 (GPIO2)
unnamed: R1.2, U$1.21 (GPIO5)
unnamed: LED2.ANODE, R2.1
RX: J1.RX, Q2.3 (D), R7.1
RX_LV: Q2.2 (S), R6.1, TP10.1, U$1.14 (UART_TX)
TX: J1.TX, Q1.3 (D), R5.1
TX_LV: Q1.2 (S), R4.1, TP11.1, U$1.13 (UART_RX)

Notes on the sheet:
1.0.5

Board: 2 copper layers, 27.9 x 39.4 mm, 20 parts (2 on the bottom side), 11 nets.

## EAGLE design 0303_phonejack/PCB/303_phonejack.brd

Parts:
BSS138: MOSFET-NCHANNELSMD; SOT23-3
C1, C2: 1u; EIA0603-CAP
J1: 0; BRICK_SERIAL
LOGO1: LOGO_FABO-M; LOGO_FABO_M
PJ1: MJ-4PP-9; PHONEJACK-MJ-4PP-9
R1: 100k; EIA0603-RES
R2: 22k; EIA0603-RES
R3: 4.7k; EIA0603-RES
R4: 3k; EIA0603-RES
R6: 10K; 0603-RES
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
+5V: J1.VCC, R1.2, R6.2
GND: BSS138.2 (S), J1.GND, PJ1.B, R2.1, R4.2
MIC: PJ1.A, R3.2, R4.1
unnamed: C2.1, R3.1
unnamed: C1.1, PJ1.C
RX: C2.2, J1.RX
TX_HV: BSS138.3 (D), J1.TX, R6.1
TX_LV: BSS138.1 (G), C1.2, R1.1, R2.2

Notes on the sheet:
Beta2

Board: 2 copper layers, 27.9 x 39.4 mm, 12 parts (0 on the bottom side), 8 nets.

## EAGLE design 0304_usb_serial/PCB/304_usb_serial.brd

Parts:
C1, C2: 47pF; 0603-NARROW
C3, C5: 0.1uF; 0603-NARROW
C4: 4.7uF; 0603-NARROW
F1: POLYSWITCH; NANOSMDC035F
IC1: FT231XQ; QFN-20_FT231X
J1: FABO_BRICK_SERIAL-USB; FABO_BRICK_SERIAL_USB
LOGO1: LOGO_FABO-M_BOTTOM; LOGO_FABO_M_BOTTOM
PWR: RED; 0603-NARROW
R1, R2: 27; 0603-NARROW
R3, R4, R7: 1k; 0603-NARROW
RX: GREEN; 0603-NARROW
S1: SLIDE-SSSS810701; SSSS810701
TX: BLUE; 0603-NARROW
U$3: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
USB1: USB-MICRO_B_SMT_HIROSE; ZX62R-B-5P

Connections:
3V3: C5.2, IC1.10 (3V3OUT), IC1.11 (RESET), IC1.20 (VCCIO), S1.1
5V: C3.2, C4.2, F1.2, IC1.12 (VCC), PWR.ANODE, RX.ANODE, S1.3, TX.ANODE
CBUS1: IC1.14 (CBUS1), R3.1
CBUS2: IC1.7 (CBUS2), R4.1
GND: C1.1, C2.1, C3.1, C4.1, C5.1, IC1.3 (GND), IC1.13 (GND), IC1.21 (GND), J1.GND, R7.1, USB1.5 (GND)
unnamed: PWR.CATHODE, R7.2
unnamed: C2.2, R2.1, USB1.2 (D-)
unnamed: C1.2, R1.1, USB1.3 (D+)
unnamed: R3.2, RX.CATHODE
unnamed: R4.2, TX.CATHODE
RXD: IC1.17 (TXD), J1.RX
TXD: IC1.1 (RXD), J1.TX
USBDM: IC1.9 (USBDM), R2.2
USBDP: IC1.8 (USBDP), R1.2
VBUS: F1.1, USB1.1 (VBUS)
VOUT: J1.VCC, S1.2

Notes on the sheet:
1.0.5

Board: 2 copper layers, 27.9 x 38.1 mm, 20 parts (0 on the bottom side), 16 nets.

## EAGLE design 0304_usb_serial/PCB/alfa/304_usb_serial.brd

Parts:
C1, C2: 47pF; 0603-NARROW
C3, C5, C7: 0.1uF; 0603-NARROW
C4: 4.7uF; 0603-NARROW
C6: 0.01uF; 0603-NARROW
F1: 350mA; NANOSMDC035F
IC1: FT231XQ; QFN-20_FT231X
J1: FABO_SERIAL_DIPINVERSE; FABO_BRICK_SERIAL_B
J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12: PIN_HEADER_1X1_NOLABEL_C; PIN_1X1_NOLABEL
JP1: PINHD-1X3; 1X03
L1: 600/0.5A; RESC0805_L
PWR: RED; 0603-NARROW
R1, R2: 27; 0603-NARROW
R3, R4: 470; 0603-NARROW
R5: 0; 0603-NARROW
R6: 10K; 0603-NARROW
R7: 1k; 0603-NARROW
R8, R9, R10: 100; 0603-NARROW
RX: GREEN; 0603-NARROW
SUPPLY: PINHD-1X2; 1X02
TP1: TPB1,27; B1,27
TP2, TP3, TP6: TPTP20SQ; TP20SQ
TP4, TP5: TPB0,65; B0,65
TX: BLUE; 0603-NARROW
U$2: LOGO_FABO-M_BOTTOM; LOGO_FABO_MS_BOTTOM
U$3: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
U$4: ZX62D-B-5PA8(30)
U$5: FABO_BRICK_CONLESS_SERIALUSB; FABO_BRICK_SERIAL_USB_WITHOUTCON
U$6: SN74LVC3G34DCU; VSSOP8

Connections:
3V3: C5.2, IC1.10 (3V3OUT), IC1.20 (VCCIO), J12.1, JP1.3, R6.1, RX.ANODE, TX.ANODE
5V: C3.2, C4.2, IC1.12 (VCC), J10.1, JP1.1, L1.1, PWR.ANODE
CBUS0: IC1.15 (CBUS0), J9.1
CBUS1: IC1.14 (CBUS1), R3.1, TP5.TP
CBUS2: IC1.7 (CBUS2), R4.1, TP4.TP
CBUS3: IC1.16 (CBUS3), J8.1
CTS1: IC1.6 (CTS), J6.1
DCD1: IC1.5 (DCD), J4.1
DSR1: IC1.4 (DSR), J3.1
DTR1: IC1.18 (DTR), U$6.6 (3A)
DTR2: R10.2, U$6.2 (3Y)
DTR3: J7.1, R10.1
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, IC1.3 (GND), IC1.13 (GND), IC1.21 (GND), J1.GND, J11.1, R5.2, R7.1, TP3.TP, U$4.5:GND (GND), U$6.4 (GND)
unnamed: R9.2, U$6.5 (2Y)
unnamed: F1.2, L1.2
unnamed: C2.2, R1.2, U$4.2:D- (D−)
unnamed: C1.2, R2.2, U$4.3:D+ (D+)
unnamed: PWR.CATHODE, R7.2
unnamed: R5.1, U$4.SHIELD3 (SHLD3), U$4.SHIELD4 (SHLD4), U$4.SHIELD5 (SHLD5), U$4.SHIELD6 (SHLD6)
unnamed: J2.1, R9.1
unnamed: IC1.11 (RESET), R6.2
unnamed: R8.2, U$6.7 (1Y)
unnamed: R3.2, RX.CATHODE
unnamed: R4.2, TX.CATHODE
RI1: IC1.2 (RI), J5.1
RTS1: IC1.19 (RTS), U$6.3 (2A)
RXD2: IC1.1 (RXD), J1.RX, TP2.TP
TXD1: IC1.17 (TXD), U$6.1 (1A)
TXD2: J1.TX, R8.1, TP6.TP
USBDM: IC1.9 (USBDM), R1.1
USBDP: IC1.8 (USBDP), R2.1
VBUS: C6.2, F1.1, U$4.1:VBUS (VBUS)
VCC1: C7.2, JP1.2, SUPPLY.1, TP1.TP, U$6.8 (VCC)
VCC2: J1.VCC, SUPPLY.2

Notes on the sheet:
1.0.8
VOUT
0.35A
ーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーー TXD Transmit Asynchronous Data Output 出力信号 データ送信 RXD Receving Asynchronous Data Input 入力信号 データ受信 ーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーー RTS Reauset to Send Contorol Output 出力信号 送信リクエスト CTS Clear To Send Contorol Inuput 入力信号 送信可能 ーーーーーーーーーーーーーーーーーーーーーーーーー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
MMZ2012Y601BT000
SN74LVC3G34DCU

Board: 2 copper layers, 27.9 x 38.1 mm, 48 parts (4 on the bottom side), 34 nets.

## EAGLE design 0304_usb_serial/PCB/alpha/FaBoBLOCKS/304_usb_serial020001.brd

Parts:
C1, C2: 47pF; 0402
C3, C5, C8, C9, C10: 0.1uF; 0402
C6: 0.01uF; 0402
C11: 4.7uF; 0402
F1: 350mA; NANOSMDC035F
IC1: FT231XQ; QFN-20_FT231X
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J12: PIN_HEADER_1X1_NOLABEL_C; PIN_1X1_NOLABEL
JP1: PINHD-1X3; 1X03
L1: 600/0.5A; RESC0805_L
PWR: RED; 0603-NARROW
R1, R2: 27; 0603-NARROW
R3, R4: 470; 0603-NARROW
R5: 0; 0603-NARROW
R6: 10K; 0603-NARROW
R7: 1k; 0603-NARROW
R8, R9, R10: 100; 0603-NARROW
R11, R12: 5.1K; 0603-NARROW
RJ11: MODULAR-JACK-6P-RJ11_SERIAL_S_USART; 7002-6PXC-X
RX: GREEN; 0603-NARROW
SUPPLY: PINHD-1X2; 1X02
TX: BLUE; 0603-NARROW
U$2: LOGO_FABO-M_BOTTOM; LOGO_FABO_MS_BOTTOM
U$4: 5077CR-16-SMC2-BK-TR
U$6, U$7, U$8: SN74AHCT1G125-Q1; SC70

Connections:
3V3: C5.2, IC1.10 (3V3OUT), IC1.20 (VCCIO), J12.1, JP1.3, R6.1, RX.ANODE, TX.ANODE
5V: C3.2, C11.2, IC1.12 (VCC), J10.1, JP1.1, L1.1, PWR.ANODE
CBUS0: IC1.15 (CBUS0), J9.1
CBUS1: IC1.14 (CBUS1), R3.1
CBUS2: IC1.7 (CBUS2), R4.1
CBUS3: IC1.16 (CBUS3), J8.1
CTS1: IC1.6 (CTS), RJ11.4 (4:CTS)
DCD1: IC1.5 (DCD), J4.1
DSR1: IC1.4 (DSR), J3.1
DTR1: IC1.18 (DTR), U$8.2 (A)
DTR3: J7.1, R10.1
D_MINUS: C2.2, R1.2, U$4.A7:DN1 (DN1), U$4.B7:DN2 (DN2)
D_PULUS: C1.2, R2.2, U$4.A6:DP1 (DP1), U$4.B6:DP2 (DP2)
GND: C1.1, C2.1, C3.1, C5.1, C6.1, C8.1, C9.1, C10.1, C11.1, IC1.3 (GND), IC1.13 (GND), IC1.21 (GND), J1.1, R5.2, R7.1, R11.2, R12.2, RJ11.1 (1:GND), U$4.A1,B12:GND (GND), U$4.B1,A12:GND (GND), U$6.1 (OE), U$6.3 (GND), U$7.1 (OE), U$7.3 (GND), U$8.1 (OE), U$8.3 (GND)
unnamed: R9.2, U$7.4 (Y)
unnamed: C6.2, F1.2, L1.2
unnamed: R11.1, U$4.B5:CC2 (CC2)
unnamed: R12.1, U$4.A5:CC1 (CC1)
unnamed: PWR.CATHODE, R7.2
unnamed: R10.2, U$8.4 (Y)
unnamed: IC1.11 (RESET), R6.2
unnamed: R3.2, RX.CATHODE
unnamed: R4.2, TX.CATHODE
RI1: IC1.2 (RI), J5.1
RTS1: IC1.19 (RTS), U$7.2 (A)
RTS2: R9.1, RJ11.2 (2:RTS)
RXD2: IC1.1 (RXD), J6.1, RJ11.5 (5:RX)
SHILED: R5.1, U$4.SHILED1, U$4.SHILED2, U$4.SHILED3, U$4.SHILED4, U$4.SHILED5 (SHILED1), U$4.SHILED6 (SHILED2), U$4.SHILED7 (SHILED3), U$4.SHILED8 (SHILED4)
TXD1: IC1.17 (TXD), U$6.2 (A)
TXD2: J2.1, R8.1, RJ11.6 (6:TX)
TXD3: R8.2, U$6.4 (Y)
USBDM: IC1.9 (USBDM), R1.1
USBDP: IC1.8 (USBDP), R2.1
VBUS: F1.1, U$4.A4,B9:VBUS (VBUS), U$4.B4,A9:VBUS (VBUS)
VCC1: C8.2, C9.2, C10.2, JP1.2, SUPPLY.1, U$6.5 (VCC), U$7.5 (VCC), U$8.5 (VCC)
VCC2: RJ11.3 (3:VCC), SUPPLY.2

Notes on the sheet:
2.0.1
VOUT
0.35A
ーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーー TXD Transmit Asynchronous Data Output 出力信号 データ送信 RXD Receving Asynchronous Data Input 入力信号 データ受信 ーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーーー RTS Reauset to Send Contorol Output 出力信号 送信リクエスト CTS Clear To Send Contorol Inuput 入力信号 送信可能 ーーーーーーーーーーーーーーーーーーーーーーーーー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
MMZ2012Y601BT000

Board: 2 copper layers, 44.4 x 32.0 mm, 48 parts (0 on the bottom side), 36 nets.

Other parts of the board:
U$3, U$5: 4-1BLOCK

Notices in the files:
parts and their libraries:
FaBo-Template: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
SparkFun: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
