# Repository FaBoPlatform/FaBo (continued)

## EAGLE design 0608_donkeycar/InspectionFixture/Testing FixtureForAICarBoard.brd

Parts:
BT1, BT2: TS-06104
C1, C2: 18pF; 0603-BOTTOM
C3, C34: 47uF; 0603-BOTTOM
C4, C5, C6, C7: 1uF; 0603-BOTTOM
C8, C9, C10: 10uF; 0603-BOTTOM
C11, C12, C13, C15, C16, C17, C18, C19, C20, C21, C22, C24, C32, C33, C35: 0.1uF; 0603-BOTTOM
C14, C23, C25, C26, C27, C29: 4.7uF; 0603-BOTTOM
C28: 1nF; 0603-BOTTOM
C30, C31: 15pF; 0603-BOTTOM
CN1: PIN_1X3
CN2, CN3, CN4, CN5, CN6: PIN_1X1-SMALL; PIN_1X1_SMALL
CON1: RASPBERRYPI_SHEILD; RASPBERRY_PI_SHILED
CON2: 5077CR-16-SMC2-BK-TR
CON3: FABO_BRICK_I2C-S04B-PASK-2; FABO_BRICK_I2C_S04B-PASK-2
D1: 1N4148; 1N4148W
D2: PMEG6010ELR-Q; SOD123W
D4: LM66100; SC-70
F1: POLYSWITCH1206; 1206
L1: MLP2520S2R2MT0S1; 1008(2520MM)
L2: AOTA-B201610S3R3-101-T; 0806(2016MM)
LED1: LED-0603; 0603
LED2: WS2812B_NARROW
OSC: ABM8-272-T3
R1, R2: 5.1K; 0603-BOTTOM
R3, R4, R28: 33; 0603-BOTTOM
R5: 5.6K; 0603
R6, R40: 10K; 0603
R7, R8, R35: 100K; 0603-BOTTOM
R9, R10, R16, R17, R18, R19, R20, R21, R22, R23: 4.7K; 0603-BOTTOM
R11, R12, R24, R25: DNP; 0603-BOTTOM
R13, R30, R34: 10K; 0603-BOTTOM
R14, R32, R33: 100; 0603-BOTTOM
R15: 390K; 0603-BOTTOM
R26: 200; 0603-BOTTOM
R27: 1; 0603-BOTTOM
R29, R31: 1K; 0603-BOTTOM
R36: 470; 0603-BOTTOM
R37, R38: 100K; 0603
U1: RP2350A; QFN60
U2: W25Q32RVXHJQ; XSON8
U3: TXB0104; TSSOP-14
U4: RT6150B-33GQW; WDFN-10L_2.5X2.5MM
U5: DMG1012T; SOT-523
U6: MCP3008; SOIC-16
U7: ER-OLED0.96-1ER-CON30HT-1_REV2; ER-CON30HT-1_REV2

Connections:
1V1: C22.2, C23.2, C24.2, C26.2, L2.2 (1), U1.6 (6:DVDD), U1.23 (23:DVDD), U1.39 (39:DVDD), U1.50 (50:VRGE_FB)
5V2: C35.2, CON1.2 (2:5V_POWER), D4.1 (VIN)
ADC-VREF: R26.1, R27.2
CLK: U3.13 (B1), U6.13 (13:CLK)
CS: U3.10 (B4), U6.10 (10:CS)
DATA: CN1.3, R33.2
DIN: U3.11 (B3), U6.11 (11:DIN)
DOUT: U3.12 (B2), U6.12 (12:DOUT)
GND: BT1.A, BT1.B, BT2.C, BT2.D, C1.1, C2.1, C3.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, CN1.2, CN6.1, CON1.9 (9:GND), CON1.14 (14:GND), CON1.20 (20:GND), CON1.25 (25:GND), CON1.30 (30:GND), CON1.34 (34:GND), CON1.39 (39:GND), CON2.A1,B12:GND (GND), CON2.B1,A12:GND (GND), CON2.SHILED1, CON2.SHILED2, CON2.SHILED3, CON2.SHILED4, CON2.SHILED5 (SHILED1), CON2.SHILED6 (SHILED2), CON2.SHILED7 (SHILED3), CON2.SHILED8 (SHILED4), CON3.GND, D4.2 (GND), D4.3 (CE), LED1.CATHODE, LED2.3-VSS (VSS), OSC.2 (#2), OSC.4 (#4), R1.2, R2.2, R6.1, R8.1, R15.1, R35.1, R38.1, U1.47 (47:VREG_PGND), U1.61 (61:GND), U1.P$62 (61:GND), U1.P$63 (61:GND), U1.P$64 (61:GND), U1.P$65 (61:GND), U1.P$66 (61:GND), U1.P$67 (61:GND), U1.P$68 (61:GND), U1.P$69 (61:GND), U1.P$70 (61:GND), U2.4 (4:VSS), U2.9 (4:VSS), U3.7 (GND), U4.3 (3:GND), U4.9 (9:GND), U4.PAD (3:GND), U6.9 (9:DGND), U6.14 (14:AGND), U7.2 (VLSS), U7.6 (D7), U7.7 (D6), U7.8 (D5), U7.9 (D4), U7.10 (D3), U7.14 (E/RD#), U7.15 (R/W#), U7.16 (D/C#), U7.18 (CS#), U7.19 (BS2), U7.21 (BS0), U7.23 (VSS)
GP0: CN4.1, R24.2, U1.2 (2:GPIO00)
GP1: CN5.1, R25.2, U1.3 (3:GPIO01)
GP10: CN2.1, U1.14 (14:GPIO10)
GP12: CN3.1, U1.16 (16:GPIO12)
GP22: R35.2, U1.34 (34:GPIO22), U3.8 (OE)
GP25: R36.2, U1.37 (37:GPIO25)
GPIO21: LED2.4-DIN (DIN), U1.31 (31:GPIO19)
GPIO23: R8.2, U1.35 (35:GPIO23), U4.7 (7:PS)
GPIO24: R5.1, R6.2, U1.36 (36:GPIO24)
GPIO29: U1.43 (43:GPIO29_ADC3), U5.S (2:SOURCE)
MINUS: CON2.A7:DN1 (DN1), CON2.B7:DN2 (DN2), R3.1
unnamed: CON2.A5:CC1 (CC1), R1.1
unnamed: CON2.B5:CC2 (CC2), R2.1
unnamed: D4.5 (ST), R40.1
unnamed: C4.1, U7.26 (C1N)
unnamed: R23.2, U6.1 (1:CH0)
unnamed: L1.1, U4.4 (4:LX1)
unnamed: L1.2, U4.2 (2:LX2)
unnamed: R7.1, U4.6 (6:EN)
unnamed: R22.2, U6.2 (2:CH1)
unnamed: C4.2, U7.27 (C1P)
unnamed: R21.2, U6.3 (3:CH2)
unnamed: R20.2, U6.4 (4:CH3)
unnamed: R19.2, U6.5 (5:CH4)
unnamed: C5.1, U7.28 (C2N)
unnamed: R18.2, U6.6 (6:CH5)
unnamed: C5.2, U7.29 (C2P)
unnamed: R17.2, U6.7 (7:CH6)
unnamed: R15.2, U7.5 (IREF)
unnamed: C8.2, U7.4 (VCOMH)
unnamed: C9.2, U7.3 (VCC)
unnamed: R14.1, U7.17 (RES#), U7.20 (BS1)
unnamed: C10.2, D1.ANODE, R13.1, R14.2
unnamed: R16.2, U6.8 (8:CH7)
unnamed: C14.2, R27.1, U1.44 (44:ADC_AVDD)
unnamed: C32.2, R37.1, R38.2, U5.D (3:DRAIN)
unnamed: BT1.C, BT1.D, R29.2
unnamed: LED1.ANODE, R36.1
NC1: CON1.4 (4:5V_POWER)
NC2: CON1.6 (6:GND)
OSC-IN: C31.2, OSC.3 (#3), U1.21 (21:XIN)
OSC-OUT: C30.2, OSC.1 (#1), R31.2
PIN11: CON1.11 (11:GPIO17(GPIO_GEN0)), R16.1
PIN13: CON1.13 (13:GPIO27(GPIO_GEN2)), R17.1
PIN15: CON1.15 (15:GPIO22(GPIO_GEN3)), R18.1
PIN29: CON1.29 (29:GPIO5), R19.1
PIN31: CON1.31 (31:GPIO6), R20.1
PIN33: CON1.33 (33:GPIO13(PWM1)), R21.1
PIN35: CON1.35 (35:GPIO19(PCM_FS)), R22.1
PIN37: CON1.37 (37:GPIO26), R23.1
PLUS: CON2.A6:DP1 (DP1), CON2.B6:DP2 (DP2), R4.1
QSPI-CLK: U1.56 (56:QSPI_SCLK), U2.6 (6:CLK)
QSPI-SD0: U1.57 (57:QSPI_SD0), U2.5 (5:DI)
QSPI-SD1: U1.59 (59:QSPI_SD1), U2.2 (2:DO)
QSPI-SD2: U1.58 (58:QSPI_SD2), U2.3 (3:WP)
QSPI-SD3: U1.55 (55:QSPI_SD3), U2.7 (7:HOLD,REST)
QSPI-SS: R29.1, R30.1, U1.60 (60:QSPI_SS), U2.1 (1:/CS)
RUN: BT2.A, BT2.B, R34.1, U1.26 (26:RUN)
SCL: CON3.SCL, R10.1, R12.1, U1.28 (28:GPIO17), U7.13 (D0)
SCL-PASPI: CON1.5 (5:GPIO3(I2C1_SCL)), R12.2
SDA: CON3.SDA, R9.1, R11.1, U1.27 (27:GPIO16), U7.11 (D2), U7.12 (D1)
SDA-RASPI: CON1.3 (3:GPIO2(I2C1_SDA)), R11.2
SPI-RX: U1.7 (7:GPIO04), U3.3 (A2)
SPI-SCLK: U1.4 (4:GPIO02), U3.2 (A1)
SPI_CS: U1.8 (8:GPIO05), U3.5 (A4)
SPI_TX: U1.5 (5:GPIO03), U3.4 (A3)
SWCLK: R32.1, U1.24 (24:SWCLK)
SWD: R33.1, U1.25 (25:SWD)
SW_CLK: CN1.1, R32.2
UNDER: CON1.8 (8:GPIO14(UART_TX)), R25.1
UPWARD: CON1.10 (10:GPIO15(UART_RX)), R24.1
USB_DM: C1.2, R3.2, U1.51 (51:USB_DM)
USB_DP: C2.2, R4.2, U1.52 (52:USB_DP)
VBUS: CON2.A4,B9:VBUS (VBUS), CON2.B4,A9:VBUS (VBUS), F1.1
VBUS-2: D2.2 (ANODE), F1.2, R5.2
VRGE_AVDD: C25.2, R28.1, U1.46 (46:VRGE_AVDD)
VRGE_LV: L2.1 (2), U1.48 (48:VRGE_LX)
VSYS: C11.2, C12.2, C33.2, C34.2, CON3.VCC, D2.1 (CATHODE), D4.6 (VOUT), LED2.1-VDD (VDD), R7.2, R37.2, R40.2, U3.14 (VCCB), U4.5 (5:VIN), U4.8 (8:VINA), U6.15 (15:VREF), U6.16 (16:VDD)
VSYS_3V3: C3.2, C6.2, C7.2, C13.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C27.2, C28.2, C29.2, D1.CATHODE, R9.2, R10.2, R13.2, R26.2, R28.2, R30.2, R34.2, U1.1 (1:IOVDD), U1.11 (11:IOVDD), U1.20 (20:IOVDD), U1.30 (30:IOVDD), U1.38 (38:IOVDD), U1.45 (45:IOVDD), U1.49 (49:VRGE_VIN), U1.53 (53:USB_DTP_VDD), U1.54 (54:QSPI_IOVDD), U2.8 (8:VCC), U3.1 (VCCA), U4.1 (1:VOUT), U4.10 (10:FB), U5.G (1:GATE), U7.22 (VDD), U7.25 (VBAT)
XOUT: R31.1, U1.22 (22:XOUT)

Notes on the sheet:
1.0.1
1N4148
OLED（青色）
シングルボードコンピュータGPIOピン
DMG1012T
Testing Jig For AI Car Board Rev1.0.1 2025/06/05 DKFA-JIG-01
12MHz,10pF
電圧計測
レベルダウン
RESET
BOOT（フラッシュメモリを読み込めない状態にして、 フラッシュメモリをマストスレージにする）
Rev1.0.0 初版 Rev1.0.1 2025/05/27 C34コンデンサ47uF追加、発振器マーキングポイント追加、アナログ系の電源の定数を変更、レベル変換A側電源断線修正、3.3V配線の見直し、正確な測定にするため、理想ダイオード追加
LM66100

Board: 2 copper layers, 65.0 x 56.5 mm, 103 parts (45 on the bottom side), 87 nets.

Other parts of the board:
LOGO1, LOGO2: LOGO_FABO_M
