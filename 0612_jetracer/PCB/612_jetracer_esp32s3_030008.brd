# Repository FaBoPlatform/FaBo

## EAGLE design 0612_jetracer/PCB/612_jetracer_esp32s3_030008.brd

Parts:
C1: 10uF; 0402
C2, C11, C12, C19: 0.1uF; 0603
C3: 10pF; 0402
C4, C5, C6, C7, C18: 1uF; 0603
C8, C9, C10, C15: 10uF; 0603
C13, C14: 0.1uF; 0402
C16: 2.2uF; 0603
C17: 0.01uF; 0603
CH1, CH2, CH3: 3P-SCN
CON1: JETSON_NANOJETSON_ORIN_NANO; JETSON_ORIN_NANO_DIMENTION
D1: 1N4148; 1N4148W
D2: CUS05F40
D3: CUHS20S30; US2H
I2C0: FABO_BRICK_I2C-B04B-PASK-1; FABO_BRICK_I2C_B04B-PASK-1
IC1: PCA9685PW,BS; PCA9685
IC3, IC4: SN74AHCT1G125; SOT-1DOT1
IC5: MC74VHC157; MC74VHC157_TSSOP-16
IC6: LP2985-33DBVR; SOT-23-5
LED1: APA102_IPIXEL; APA102_2020
R1, R40, R41: DNP; 0603
R2, R22, R38: 4.7K; 0603
R3, R4: 220; 0603
R5, R6: DNF; 0603
R7: 390K; 0603
R8, R9: 10K; 0603
R10, R34, R35: 100; 0603
R11: DNP; 0805
R12: 0/0805; 0805
R13, R14: 22; 0603
R15, R16, R23, R25, R26: 470; 0603
R17, R18, R24: 100K; 0603
R19, R20, R27, R36, R37: 1K; 0603
R21: 180; 0603
R28, R29, R30, R31, R32, R33: 10K; 0402
R39: 510; 0805
RC: ORANGE; 0603
SPI-LED: FABO-SPI-LED-B04B; SPI-B04B-PASK-1
ST: 3P-SCN
T1, T2, T3: MOSFET-N_FDN335N; SUPERSOT-3
T4, T5: RN1401; SC-59
TH: 3P-SCN
U1: KC2016Z
U2: ER-OLED0.96-1ER-CON30HT-1; ER-CON30HT-1
U3: TLP2270
U4: TLP291A; 11-3C1
U5: MOUDLE-SEEEDUINO-XIAO-ESP32C3SINGLESIDE; MOUDLE14P-DIP_SINGLE

Connections:
3V3_JETSON: C1.2, C2.2, C6.2, C7.2, C11.2, C12.2, CON1.1 (3V3), CON1.17 (3V3), D1.CATHODE, IC1.28 (VDD), R2.2, R5.2, R6.2, R8.1, R9.1, R11.2, U1.#1 (1:INH), U1.#4 (4:VCC), U2.22 (VDD), U2.25 (VBAT), U3.8 (8:VDD_), U4.4 (COL)
5VL_JETSON: D3.K (CATHODE), U5.14 (5V)
5V_JETSON: C13.2, C14.2, C15.2, CON1.2 (5V), D3.A (ANODE), I2C0.VCC, IC3.5 (5:VCC), IC4.5 (5:VCC), LED1.VCC, R39.2, SPI-LED.VCC
AI_CH1_ST: IC5.2 (2:A0), R3.2
AI_CH2_TH: IC5.5 (5:A1), R4.2
BEC_3V3: C16.2, C19.2, IC5.16 (16:VCC), IC6.5 (VOUT), R38.1, T4.B
BEC_60: C18.2, D2.C (CATHODE), IC6.1 (VIN), IC6.3 (ON/OFF)
BEC_62: CH1.2, CH2.2, CH3.2, D2.A (ANODE), R19.2, R20.2, RC.ANODE, ST.2, TH.2, U4.1 (A)
CE0: CON1.24 (CE0)
CLK2: LED1.CKO, SPI-LED.CI
CLK_HV: IC4.4 (4:Y), LED1.CKI
EXCLK: C3.2, IC1.25 (EXTCLK), R1.2, U1.#3 (3:OUTPUT)
GND: C1.1, C2.1, C3.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, CH1.3, CH2.3, CH3.3, CON1.9 (GND), CON1.14 (GND), CON1.20 (GND), CON1.25 (GND), CON1.30 (GND), CON1.34 (GND), CON1.39 (GND), I2C0.GND, IC1.1 (A0), IC1.2 (A1), IC1.3 (A2), IC1.4 (A3), IC1.5 (A4), IC1.14 (VSS), IC1.24 (A5), IC3.1 (1:OE), IC3.3 (3:GND), IC4.1 (1:OE), IC4.3 (3:GND), IC5.8 (8:GND), IC5.15 (15:E), IC6.2 (GND), LED1.GND, R1.1, R7.2, R12.1, R17.2, R18.2, R22.2, R24.2, R27.1, R28.2, R29.2, R30.2, R31.2, R32.2, R33.2, R36.1, R37.1, R39.1, R40.1, SPI-LED.GND, ST.3, T1.S, T2.S, T3.S, T4.E, T5.E, TH.3, U1.#2 (2:CASE_GND), U2.2 (VLSS), U2.6 (D7), U2.7 (D6), U2.8 (D5), U2.9 (D4), U2.10 (D3), U2.14 (E/RD#), U2.15 (R/W#), U2.18 (CS#), U2.19 (BS2), U2.21 (BS0), U2.23 (VSS), U3.5 (5:GND), U5.13 (GND)
GPIO4: CON1.7 (GPIO4)
GPIO5: CON1.29 (GPIO5)
GPIO6: CON1.31 (GPIO6)
GPIO12: CON1.32 (GPIO12)
GPIO13: CON1.33 (GPIO13)
GPIO16: CON1.36 (GPIO16)
GPIO17: CON1.11 (GPIO17)
GPIO18: CON1.12 (GPIO18)
GPIO19: CON1.35 (GPIO19)
GPIO20: CON1.38 (GPIO20)
GPIO21: CON1.40 (GPIO21)
GPIO22: CON1.15 (GPIO22)
GPIO23: CON1.16 (GPIO23)
GPIO24: CON1.18 (GPIO24)
GPIO25: CON1.22 (GPIO25)
GPIO26: CON1.37 (GPIO26)
GPIO27: CON1.13 (GPIO27)
LED0: IC1.6 (LED0), R3.1
LED1: IC1.7 (LED1), R4.1
MISO: CON1.21 (MISO)
MOSI: CON1.19 (MOSI)
MOSI1: IC3.2 (2:A), U5.11 (PA6_A10_D10_MOSI)
MOSI2: LED1.SDO, SPI-LED.DI
MOSI_HV: IC3.4 (4:Y), LED1.SDI
MUX_SELECT: IC5.1 (1:S), R38.2, R41.2, T5.C
unnamed: IC5.9 (9:Y2), R33.1
unnamed: C5.2, U2.29 (C2P)
unnamed: IC5.10 (10:B2), R32.1
unnamed: R21.1, U4.2 (C)
unnamed: R20.1, U3.4 (4:AN2)
unnamed: R19.1, U3.1 (1:AN1)
unnamed: R7.1, U2.5 (IREF)
unnamed: C4.2, U2.27 (C1P)
unnamed: C9.2, U2.3 (VCC)
unnamed: R10.2, U2.17 (RES#)
unnamed: IC5.11 (11:A2), R31.1
unnamed: IC5.12 (12:Y3), R30.1
unnamed: C4.1, U2.26 (C1N)
unnamed: C5.1, U2.28 (C2N)
unnamed: R23.1, R24.1, T3.G
unnamed: R27.2, RC.CATHODE
unnamed: C8.2, U2.4 (VCOMH)
unnamed: R21.2, T3.D
unnamed: T2.D, U3.3 (3:CA2)
unnamed: T1.D, U3.2 (2:CA1)
unnamed: IC5.13 (13:B3), R29.1
unnamed: C10.2, D1.ANODE, R9.2, R10.1
unnamed: R15.2, R17.1, T1.G
unnamed: IC5.14 (14:A3), R28.1
unnamed: R11.1, R12.2, U2.16 (D/C#)
unnamed: R16.2, R18.1, T2.G
unnamed: C17.2, IC6.4 (BYPASS)
unnamed: R8.2, U2.20 (BS1)
NC0: CON1.4 (5V)
NC1: CON1.6 (GND)
NC5: U5.10 (PA5_A9_D9_MISO)
OE: IC1.23 (OE), R2.1, R40.2, T4.C
PCH1: CH1.1, R13.1
PCH1_3V3: U3.7 (7:OUT1), U5.1 (PA02_A0_D0)
PCH2: CH2.1, R14.1
PCH2_3V3: U3.6 (6:OUT2), U5.2 (PA4_A1_D1)
PCH3_XAIO: R22.1, U4.3 (EMI), U5.3 (PA10_A2_D2)
PCH_3: CH3.1, R23.2
RCH1: IC5.4 (4:Y0), R34.1, R36.2
RCH2: IC5.7 (7:Y1), R35.1, R37.2
RC_CH1_ST: R34.2, ST.1
RC_CH2_TH: R35.2, TH.1
RECV_CH1: IC5.3 (3:B0), R25.2
RECV_CH1_H: R13.2, R15.1, R25.1
RECV_CH2: IC5.6 (6:B1), R26.2
RECV_CH2_H: R14.2, R16.1, R26.1
RX: CON1.10 (RX)
SCK1: IC4.2 (2:A), U5.9 (PA7_A8_D8_SCK)
SCL: CON1.5 (SCL), I2C0.SCL, IC1.26 (SCL), R5.1, U2.13 (D0), U5.6 (PA9_A5_D5_SCL)
SCLK: CON1.23 (SCLK)
SDA: CON1.3 (SDA), I2C0.SDA, IC1.27 (SDA), R6.1, U2.11 (D2), U2.12 (D1), U5.5 (PA8_A4_D4_SDA)
SIGNAL_SELCET: R41.1, T5.B, U5.4 (PA11_A3_D3)
TX: CON1.8 (TX)
XIAO3V3: U5.12 (3V3)
XIAO_RX: U5.8 (PB09_A7_D7_RX)
XIAO_TX: U5.7 (PB08_A6_D6_TX)

Notes on the sheet:
3.0.8 B
PWM Controller
Address 0x40
MULTIPLEXERS
Reciver
*Signal from radio control receiver
*Signal to the Servo
steering
throttle
Expansion channel
ESC
SPI_LED_OUTLET
RC_Car Connect Receiver and ESC,Servo
CRISTAL OSCILLATOR
I2C
1N4148
OLED
Rev3.0.8
SPI_LED
XIAO-ESP32S3
SELECT Low:A0-A3 High:B0-B3
Bottom Connector
Residual measures
I2S,SPI,PWM0,PWM1のコネクタ廃止
Rev3.0.3回路継承
3V3 Supply
JST PA 4Pin Side
主な変更点
マルチプレクサ電源衝突防止のためデジトラ追加
マルチプレクサ論理反転のためA,Bスワップ
マルチプレクサ空きポート保護抵抗追加
R 15,R16,R 29,R 27,R 10,R12,14削除
2024/11/05,2024/11/20,2026/04/08
※BEC電源は電圧６V~7V 急加速、急減速による電圧降下に注意
Jetson Nano 互換（B)
Addtion(PCA9685 OUTPUT Enable and Disable)
PinSwap
※注釈の領域はRev3.0.3との差分です。
Addtion
Adjustment Value

Board: 2 copper layers, 82.0 x 62.5 mm, 90 parts (21 on the bottom side), 65 nets.

Other parts of the board:
U$1, U$2: LOGO_FABO_M

Notices in the files:
parts and their libraries:
FaBo-Resistors: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
