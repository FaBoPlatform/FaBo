# Repository FaBoPlatform/FaBo (continued)

## EAGLE design 0612_jetracer/PCB/612_jetracer_esp32s3_030005.brd

Parts:
1: 3P-SCN
C1, C12, C13, C15, C16: 10uF; 0603
C2, C4, C5, C9, C11, C20, C26: 0.1uF; 0603
C3: 20pF; 0402
C6: 0.01uF; 0603
C7: 2.2uF; 0603
C8, C17, C18, C19, C22: 1uF; 0603
C10, C14, C21, C23, C27, C28, C29, C30: 0.1uF; 0402
C24, C25: 22pF; 0402
CH2, CH3, CH4, CH5: 3P-SCN
D1: 1N4148; 1N4148W
D2: CUS05F40
D3: CUHS20S30; US2H
ESC_CON: BRUSHLESSMOTOR_CON; B6B-ZR
EXT1: FABO-I2S-2; I2S-B08B-PASK-1
EXT2: FABO-SPI-7PIN; SPI-B07B-PASK-1
GP12: FABO_BRICK_3PIN-B03B-PASK-1; FABO_BRICK_3PIN_B03B-PASK-1
GP13: FABO-GPIO-2G; GPIO-B04B-PASK-1
GPIO40: JETSON_NANOJETSON_NANO_OVERALL; JETSON_NANO_DEMENTION
I2C: FABO-I2C; I2C-SM04B-PASS-1-FL
IC1: LP2985-33DBVR; SOT-23-5
IC2: PCA9685PW,BS; PCA9685
LED1: APA102_IPIXEL; APA102_2020
MOTOR: BRUSHLESSMOTOR_CON; B6B-ZR
Q1, Q2, Q3, Q4, Q5: MOSFET-N_FDN335N; SUPERSOT-3
R1, R27, R29, R53, R63, R64: DNP; 0603
R2, R4: 220; 0402
R3, R10, R14: 0; 0603
R5, R24, R32, R33, R41, R42, R55, R62: 100K; 0603
R6, R60, R68: 4.7K; 0603
R7, R46, R66: 1K; 0402
R8, R34, R35, R54, R61: 470; 0603
R9, R17, R45, R47, R48, R49, R57, R58, R59, R65, R69, R70, R71, R73, R74, R75, R76, R77, R78, R79: 10K; 0402
R11, R12, R50, R51, R52: 22; 0603
R13: 390K; 0603
R15, R16: 680; 0603
R18, R20, R21, R30, R38: 51; 0603
R19, R25: 10K; 0603
R22, R23, R39, R40, R43, R44: DNF; 0603
R26, R56, R67: 180; 0603
R28: 510; 0805
R31: 100; 0603
R36: 0/0805; 0805
R37: DNP; 0805
R72: DNP; 0402
RCPWR: ORANGE; 0603
SPI-LED: FABO-SPI-LED; SPI-SM04B-PASS-1-FL
ST: 3P-SCN
T1: DTC114EU3; SOT-323FL/SC-85(UMT3F)
TH: 3P-SCN
TP1, TP2, TP3, TP4, TP5: TESTPOINT_TPS-SMD-10SN; TESTPOINT_SMD-10SN
U1: TLP2270
U2, U3, U4: TLP291A; 11-3C1
U7: ER-OLED0.96-1ER-CON30HT-1; ER-CON30HT-1
U$1: MC74VHC157; MC74VHC157_TSSOP-16
U$3, U$5: TC7WZ07FK; SOT-765
U$9, U$10: SN74AHCT1G125; SOT-1DOT1
U$11: KC2016Z
U$13: BNO055; LGA
U$14: ESP32S3DEVKITC-1-DUAL
X1: FC-135

Connections:
3V3_JETSON: C2.2, C4.2, C9.2, C11.2, C15.2, C17.2, C18.2, C20.2, C27.2, C28.2, C29.2, C30.2, D1.CATHODE, GP13.3V3 (3:3V3), GPIO40.1 (3V3), GPIO40.17 (3V3), IC2.28 (VDD), R19.1, R22.2, R23.2, R25.1, R37.2, R39.1, R43.1, R44.1, R47.2, R48.2, R59.2, R69.2, R70.2, R72.2, R73.1, U1.8 (8:VDD_), U2.4 (COL), U3.4 (COL), U4.4 (COL), U7.22 (VDD), U7.25 (VBAT), U$5.8 (8:VCC), U$11.#1 (1:INH), U$11.#4 (4:VCC), U$13.3 (3:VDD), U$13.28 (28:VDDIO)
5VL_JETSON: D3.K (CATHODE), U$14.21:5V0, U$14.21:5V0_L (21:5V0)
5V_JETSON: C1.2, C10.2, C14.2, D3.A (ANODE), EXT1.2:5V, EXT2.2 (2:5V), GP12.VCC, GP13.5V (2:5V), GPIO40.2 (5V), I2C.5V (VCC), LED1.VCC, R28.2, SPI-LED.5V (VCC), U$9.5 (5:VCC), U$10.5 (5:VCC)
AI_CH1_ST: R2.1, U$5.1 (1:1A)
AI_CH2_TH: R4.1, U$5.3 (3:2A)
BEC\MAX3A: 1.2, CH2.2, CH3.2, CH4.2, CH5.2, D2.A (ANODE), RCPWR.ANODE, ST.2, TH.2
BEC_3V3: C5.2, C7.2, IC1.5 (VOUT), R5.2, R74.1, R75.1, U$1.16 (16:VCC)
BEC_60: C8.2, D2.C (CATHODE), IC1.1 (VIN), IC1.3 (ON/OFF)
BEC_62: R15.2, R16.2, R26.2, R53.1, R56.2, R67.2
BNO_RESET: R69.1, R71.2, U$13.11 (11:NRESET)
CE0: GPIO40.24 (CE0)
CH1(ST): U1.7 (7:OUT1), U$14.4:GPIO4, U$14.4:GPIO4_L (4:GPIO4)
CH2(TH): U1.6 (6:OUT2), U$14.5:GPIO5, U$14.5:GPIO5_L (5:GPIO5)
CH3(SEL): R6.1, U2.3 (EMI), U$14.6:GPIO6, U$14.6:GPIO6_L (6:GPIO6)
CH4(OPTION1): R60.1, U3.3 (EMI), U$14.7:GPIO7, U$14.7:GPIO7_L (7:GPIO7)
CH5(OPTION5): R68.1, U4.3 (EMI), U$14.8:GPIO15, U$14.8:GPIO15_L (8:GPIO15)
CLK2: LED1.CKO, SPI-LED.CI
CLK_HV: LED1.CKI, U$10.4 (4:Y)
CLK_LV: R14.2, U$10.2 (2:A)
ESP32_MOSI1: R10.1, R76.2, U$14.17:GPIO11, U$14.17:GPIO11_L (17:GPIO11)
ESP32_SCK1: R14.1, R77.2, U$14.18:GPIO12, U$14.18:GPIO12_L (18:GPIO12)
G18: EXT1.4:BCLK, R30.2
G19: EXT1.5:LRCLK, R38.2
G21: EXT1.3:DOUT, R18.2, R41.1
GND: 1.3, C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C20.1, C21.1, C23.1, C24.2, C25.2, C26.1, C27.1, C28.1, C29.1, C30.1, CH2.3, CH3.3, CH4.3, CH5.3, ESC_CON.1 (1:GND), EXT1.1:GND, EXT1.8:GND, EXT2.1 (1:GND), GP12.GND, GP13.GND (1:GND), GPIO40.9 (GND), GPIO40.14 (GND), GPIO40.20 (GND), GPIO40.25 (GND), GPIO40.30 (GND), GPIO40.34 (GND), GPIO40.39 (GND), I2C.GND, IC1.2 (GND), IC2.1 (A0), IC2.2 (A1), IC2.3 (A2), IC2.4 (A3), IC2.5 (A4), IC2.14 (VSS), IC2.24 (A5), LED1.GND, MOTOR.1 (1:GND), Q1.S, Q2.S, Q3.S, Q4.S, Q5.S, R1.1, R3.1, R6.2, R7.2, R9.1, R13.2, R17.1, R24.2, R28.1, R32.2, R33.2, R36.1, R40.2, R41.2, R42.2, R45.1, R46.2, R49.1, R55.2, R57.1, R58.1, R60.2, R62.2, R65.1, R66.2, R68.2, SPI-LED.GND, ST.3, T1.1 (1:GND(EMITTER)), TH.3, U1.5 (5:GND), U7.2 (VLSS), U7.6 (D7), U7.7 (D6), U7.8 (D5), U7.9 (D4), U7.10 (D3), U7.14 (E/RD#), U7.15 (R/W#), U7.18 (CS#), U7.19 (BS2), U7.21 (BS0), U7.23 (VSS), U$1.8 (8:GND), U$1.15 (15:E), U$3.4 (4:GND), U$5.4 (4:GND), U$9.1 (1:OE), U$9.3 (3:GND), U$10.1 (1:OE), U$10.3 (3:GND), U$11.#2 (2:CASE_GND), U$13.2 (2:GND), U$13.18 (18:COM2), U$13.25 (25:GNDIO), U$14.1:GND_J3, U$14.1:GND_J3R (1:GND_J3), U$14.21:GND_J3, U$14.21:GND_J3_R (21:GND_J3), U$14.22:GND_J1, U$14.22:GND_J1L (22:GND_J1), U$14.22:GND_J3, U$14.22:GND_J3_R (22:GND_J3)
GPIO4: EXT1.6:MCK, GPIO40.7 (GPIO4), R39.2, R40.1
GPIO5: GPIO40.29 (GPIO5)
GPIO6: GPIO40.31 (GPIO6)
GPIO12: GP12.I/O, GPIO40.32 (GPIO12), R43.2
GPIO13: GP13.IO (4:IO), GPIO40.33 (GPIO13), R44.2
GPIO16: GPIO40.36 (GPIO16)
GPIO17: GPIO40.11 (GPIO17)
GPIO18: GPIO40.12 (GPIO18), R30.1
GPIO19: GPIO40.35 (GPIO19), R38.1
GPIO20: EXT1.7:DIN, GPIO40.38 (GPIO20), R42.1
GPIO21: GPIO40.40 (GPIO21), R18.1
GPIO22: GPIO40.15 (GPIO22), R71.1
GPIO23: EXT2.4 (4:NC), GPIO40.16 (GPIO23)
GPIO24: EXT2.3 (3:CS), GPIO40.18 (GPIO24)
GPIO25: EXT2.7 (7:MISO), GPIO40.22 (GPIO25)
GPIO26: EXT2.6 (6:MOSI), GPIO40.37 (GPIO26)
GPIO27: EXT2.5 (5:SCLK), GPIO40.13 (GPIO27)
LED0: IC2.6 (LED0), R2.2
LED1: IC2.7 (LED1), R4.2
MISO: GPIO40.21 (MISO)
MOSI: GPIO40.19 (MOSI)
MOSI2: LED1.SDO, SPI-LED.DI
MOSI_HV: LED1.SDI, U$9.4 (4:Y)
MOSI_LV: R10.2, U$9.2 (2:A)
MOTORCONTROLPOWER: C23.2, ESC_CON.6 (6:VCC), MOTOR.6 (6:VCC), U$3.8 (8:VCC)
M_SENSOR1: R47.1, U$3.7 (7:1Y), U$14.9:GPIO16, U$14.9:GPIO16_L (9:GPIO16)
M_SENSOR2: R48.1, U$3.2 (2:3Y), U$14.10:GPIO17, U$14.10:GPIO17_L (10:GPIO17)
M_SENSOR3: R59.1, U$3.5 (5:2Y), U$14.11:GPIO18, U$14.11:GPIO18_L (11:GPIO18)
unnamed: C22.2, U7.29 (C2P)
unnamed: R45.2, U$1.10 (10:B2)
unnamed: R63.1, U$14.2:GPIO43 (2:GPIO43/U0TXD), U$14.2:GPIO43_R (2:GPIO43/U0TXD)
unnamed: R26.1, U2.1 (A)
unnamed: IC2.23 (OE), R3.2
unnamed: R64.1, U$14.3:GPIO44 (3:GPIO44/U0RXD), U$14.3:GPIO44_R (3:GPIO44/U0RXD)
unnamed: R15.1, R27.2, U1.4 (4:AN2)
unnamed: IC2.21 (LED14), TP2.TP
unnamed: Q4.D, R27.1, U1.3 (3:CA2)
unnamed: R16.1, R29.1, U1.1 (1:AN1)
unnamed: Q3.D, R53.2, U2.2 (C)
unnamed: R13.1, U7.5 (IREF)
unnamed: Q1.G, R54.1, R55.1
unnamed: C19.2, U7.27 (C1P)
unnamed: C13.2, U7.3 (VCC)
unnamed: R56.1, U3.1 (A)
unnamed: R17.2, U$1.11 (11:A2)
unnamed: C19.1, U7.26 (C1N)
unnamed: C22.1, U7.28 (C2N)
unnamed: Q3.G, R8.1, R24.1
unnamed: R7.1, RCPWR.CATHODE
unnamed: C16.2, U7.4 (VCOMH)
unnamed: Q1.D, U3.2 (C)
unnamed: CH4.1, R54.2
unnamed: Q2.G, R61.1, R62.1
unnamed: R67.1, U4.1 (A)
unnamed: Q5.D, R29.2, U1.2 (2:CA1)
unnamed: R9.2, U$1.13 (13:B3)
unnamed: C12.2, D1.ANODE, R25.2, R31.1
unnamed: Q5.G, R32.1, R34.2
unnamed: Q2.D, U4.2 (C)
unnamed: R65.2, U$1.14 (14:A3)
unnamed: CH5.1, R61.2
unnamed: R36.2, R37.1, U7.16 (D/C#)
unnamed: Q4.G, R33.1, R35.2
unnamed: C6.2, IC1.4 (BYPASS)
unnamed: C3.2, IC2.25 (EXTCLK), R1.2, U$11.#3 (3:OUTPUT)
unnamed: C21.2, U$13.9 (9:CAP)
unnamed: C24.1, U$13.27 (27:XIN32), X1.1
unnamed: C25.1, U$13.26 (26:XOUT32), X1.2
unnamed: R49.2, U$13.5 (5:PS1)
unnamed: R57.2, U$13.6 (6:PS0)
unnamed: U$14.20:GPIO14, U$14.20:GPIO14_L (20:GPIO14)
unnamed: R79.2, U$14.19:GPIO13, U$14.19:GPIO13_L (19:GPIO13)
unnamed: R78.2, U$14.16:GPIO10, U$14.16:GPIO10_L (16:GPIO10)
unnamed: R19.2, U7.20 (BS1)
unnamed: U$14.14:GPIO46 (14:GPIO46/LOG), U$14.14:GPIO46_L (14:GPIO46/LOG)
unnamed: U$14.13:GPIO3 (13:GPIO3/JTAG), U$14.13:GPIO3_L (13:GPIO3/JTAG)
unnamed: R58.2, R72.1, U$13.17 (17:COM3)
unnamed: R70.1, U$13.4 (4:NBOOT)
unnamed: U$14.3:RST (3:RST(CHIP_PU)), U$14.3:RST_L (3:RST(CHIP_PU))
unnamed: U$14.1:3V3, U$14.1:3V3_L (1:3V3)
unnamed: U$14.2:3V3, U$14.2:3V3_L (2:3V3)
unnamed: U$14.20:GPIO19 (20:GPIO19/USBD-), U$14.20:GPIO19_R (20:GPIO19/USBD-)
unnamed: U$14.19:GPIO20 (19:GPIO20/USBD+), U$14.19:GPIO20_R (19:GPIO20/USBD+)
unnamed: U$14.18:GPIO21, U$14.18:GPIO21_R (18:GPIO21)
unnamed: U$14.16:GPIO48, U$14.16:GPIO48_R (16:GPIO48)
unnamed: U$14.14:GPIO0 (14:GPIO0/BOOT), U$14.14:GPIO0_R (14:GPIO0/BOOT)
unnamed: U$14.13:GPIO35, U$14.13:GPIO35_R (13:GPIO35)
unnamed: U$14.12:GPIO36, U$14.12:GPIO36_R (12:GPIO36)
unnamed: U$14.11:GPIO37, U$14.11:GPIO37_R (11:GPIO37)
unnamed: U$14.10:GPIO38, U$14.10:GPIO38_R (10:GPIO38)
unnamed: U$14.9:GPIO39, U$14.9:GPIO39_R (9:GPIO39)
unnamed: U$14.8:GPIO40, U$14.8:GPIO40_R (8:GPIO40)
unnamed: U$14.7:GPIO41, U$14.7:GPIO41_R (7:GPIO41)
unnamed: U$14.6:GPIO42, U$14.6:GPIO42_R (6:GPIO42)
unnamed: U$14.5:GPIO2 (5:GPOP2), U$14.5:GPIO2_R (5:GPOP2)
unnamed: U$14.4:GPIO1, U$14.4:GPIO1_R (4:GPIO1)
unnamed: TP3.TP, U$13.10 (10:BL_IND)
unnamed: TP4.TP, U$13.7 (7:SWDIO)
unnamed: TP5.TP, U$13.8 (8:SWCLK)
unnamed: R75.2, U$1.2 (2:A0), U$5.7 (7:1Y)
unnamed: R74.2, U$1.5 (5:A1), U$5.5 (5:2Y)
unnamed: R73.2, U$5.6 (6:3A)
NC0: GPIO40.4 (5V)
NC1: GPIO40.6 (GND)
NC_MS1: ESC_CON.5 (5:NC), MOTOR.5 (5:NC), TP1.TP
PCH1: 1.1, R12.1
PCH2: CH2.1, R11.1
PCH_3: CH3.1, R8.2
RCH1: R20.1, R46.1, U$1.4 (4:Y0)
RCH2: R21.1, R66.1, U$1.7 (7:Y1)
RC_CH1_ST: R20.2, ST.1
RC_CH2_TH: R21.2, TH.1
RECV_CH1: R12.2, R34.1, U$1.3 (3:B0)
RECV_CH2: R11.2, R35.1, U$1.6 (6:B1)
RESET_SIG: R31.2, U7.17 (RES#)
RX_JETSON: GPIO40.10 (RX), R63.2
SCL: GPIO40.5 (SCL), I2C.SCL, IC2.26 (SCL), R22.1, U7.13 (D0), U$13.19 (19:COM1), U$14.15:GPIO9, U$14.15:GPIO9_L (15:GPIO9)
SCLK: GPIO40.23 (SCLK)
SDA: GPIO40.3 (SDA), I2C.SDA, IC2.27 (SDA), R23.1, U7.11 (D2), U7.12 (D1), U$13.20 (20:COM0), U$14.12:GPIO8, U$14.12:GPIO8_L (12:GPIO8)
SEL: C26.2, R5.1, T1.3 (3:OUT(COLLECTOR)), U$1.1 (1:S)
SENSE1_ESC: ESC_CON.2 (2:SENSOR1), R50.2, U$3.1 (1:1A)
SENSE1_MOTOR: MOTOR.2 (2:SENSOR1), R50.1
SENSE2_ESC: ESC_CON.3 (3:SENSOR2), R51.2, U$3.6 (6:3A)
SENSE2_MOTOR: MOTOR.3 (3:SENSOR2), R51.1
SENSE3_ESC: ESC_CON.4 (4:SENSOR3), R52.2, U$3.3 (3:2A)
SENSE3_MOTOR: MOTOR.4 (4:SENSOR3), R52.1
SIGNAL_SELCET: T1.2 (2:IN(BASE)), U$14.17:GPIO47, U$14.17:GPIO47_R (17:GPIO47)
TX_JETSON: GPIO40.8 (TX), R64.2
VSPI: R76.1, R77.1, R78.1, R79.1, U$14.15:GPIO45 (15:GPIO45/VSPI), U$14.15:GPIO45_R (15:GPIO45/VSPI)

Notes on the sheet:
3.0.5
Jetson Nano or Jetson Nano Orin
PWM Controller
Address 0x40
MULTIPLEXERS
*Signal from radio control receiver
*Signal to the car body
steering
throttle
Expansion channel
OUT
SPI_LED_OUTLET
RC_Car Connect Receiver and ESC,Servo
CRISTAL OSCILLATOR
I2C
1N4148
OLED
Rev3.0.5
SPI_LED
SELECT Low:A0-A3 High:B0-B3
Bottom Connector
Residual measures
XIAO ESP32S3からESP32DevKitC-1への変更
Exchange 8pin
JST PA 8Pin Top
JST PA 4Pin Side
JST PA 6Pin Top
Addtion
Users Expansion Additon
主な変更点
SPI
2024/07/09
ESC SIDE
MOTOR SIDE
brushless motor
Motor Rotation Detection
Addtion pulldown resistance 102
DTC114EU3T106
Addition OpenColector
Addition

Board: 2 copper layers, 93.9 x 73.0 mm, 158 parts (41 on the bottom side), 144 nets.

Other parts of the board:
U$2: LOGO_FABO_L

Notices in the files:
parts and their libraries:
FaBo-Resistors: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
