# Repository FaBoPlatform/FaBo

## EAGLE design 0612_jetracer/PCB/612_jetracer_328_211.brd

Board: 2 copper layers, 98.9 x 53.0 mm, 68 parts (23 on the bottom side), 46 nets.

Parts:
1, 2, 3: FABO_BRICK_3PIN_HEADER
C1, C20, C24, C27, C28: 0.1uF; 0603
C2: 10uF; 0603
C3, C16: 0.1uF; 0603-BOTTOM
C5, C6, C7, C8: 1uF; 0603-BOTTOM
C9, C10, C11, C12: 10uF; 0603-BOTTOM
C14: 0.01uF; 0603
C15: 2.2uF; 0603
C21: 1uF; 0603
D1: 1N4148; 1N4148W
D2: CUS05F40
IC1: TQFP-32
IC2: JETSON_NANO_NOBORDER; JETSON_NANO_NOBOARDER
IC3: MULTIPLEXERSMC74HC157A; TSSOP-16
IC4: PCA9685
IC5: SOT-23-5
ICSP1: TC2030
JETSON: GREEN; 0603
JP1: PINHD-1X3; 1X03
Q1, Q2: MOSFET-N_FDN335N; SUPERSOT-3
R1, R2, R3, R14, R19, R22, R23: 10K; 0603
R5: 470; 0603
R7, R28: 10k; 0603-BOTTOM
R8: 100; 0603-BOTTOM
R9: 390K; 0603-BOTTOM
R10, R12, R13: 1K; 0603
R11, R18: 5.1K; 0603
R20, R31: 0; 0603
R24: 4.7K; 0603
R30: 220; 0603
RC: RED; 0603
SPI-LED: FABO-SPI-LED-B04B; SPI-B04B-PASK-1
ST: FABO_BRICK_3PIN_HEADER
TH: FABO_BRICK_3PIN_HEADER
U1: ER-CON30HT-1
U$1, U$2, U$3, U$6: MARK_POINT_3MM
U$9, U$10: SN74LVC1G17; SOT-23
U$11: LOGO_FABO_MS
X2: 16MHz; CSTNE_V_C

Connections:
0: 1.GND, 2.GND, 3.GND, C14.1, C15.1, C20.1, C21.1, C24.1, IC3.8, IC3.15, IC5.2, ST.GND, TH.GND
3V3: C3.2, C12.2, C27.1, C28.1, IC1.4, IC1.6, IC1.18, IC2.1, IC2.17, ICSP1.2, R2.2, R28.2, U$9.5, U$10.5
5V: IC2.2, SPI-LED.VCC
AVR_MISO: IC1.16, ICSP1.1
AVR_MOSI: IC1.15, ICSP1.4, SPI-LED.DI
AVR_RESET: IC1.29, ICSP1.5, R2.1
AVR_RX: IC1.30, R12.2
AVR_SCK: IC1.17, ICSP1.3, SPI-LED.CI
AVR_TX: IC1.31, R13.2
D3: IC1.1, RC.ANODE
D4: IC1.2, JETSON.ANODE
GND: C1.1, C2.1, C3.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C16.1, C27.2, IC1.3, IC1.5, IC1.21, IC2.9, IC2.14, IC2.20, IC2.25, IC2.30, IC2.34, IC2.39, IC4.1, IC4.14, IC4.24, ICSP1.6, JP1.3, R1.1, R3.1, R5.1, R9.1, R10.1, R24.1, SPI-LED.GND, U1.2, U1.6, U1.7, U1.8, U1.9, U1.10, U1.14, U1.15, U1.16, U1.18, U1.19, U1.21, U1.23, U$9.3, X2.2
unnamed: IC3.3, Q1.D, R19.1
unnamed: C1.2, IC1.20
unnamed: IC1.8, X2.3
unnamed: JP1.1, R12.1
unnamed: IC1.7, X2.1
unnamed: C6.2, U1.27
unnamed: JP1.2, R13.1
unnamed: R5.2, RC.CATHODE
unnamed: JETSON.CATHODE, R10.2
unnamed: C6.1, U1.26
unnamed: C5.1, U1.28
unnamed: C5.2, U1.29
unnamed: R9.2, U1.5
unnamed: C9.2, U1.4
unnamed: C10.2, U1.3
unnamed: R8.1, U1.17
unnamed: C11.2, D1.ANODE, R7.1, R8.2
unnamed: C14.2, IC5.4
unnamed: IC5.3, R31.2
unnamed: R20.2, ST.I/O
unnamed: Q2.G, R11.1
unnamed: Q1.G, R18.1
unnamed: IC3.6, Q2.D, R14.1
unnamed: R28.1, U1.20
PCH3: IC1.26, R24.2
RCH1: IC3.4, R20.1
S$2: R14.2, R19.2
S$7: C7.2, C8.2, D1.CATHODE, R7.2, R22.2, R23.2, U1.22, U1.25
S$8: R22.1, U1.13
SCL: IC1.28, IC2.5
SDA: IC1.27, IC2.3, R23.1, U1.11, U1.12
VCC_R: C20.2, C21.2, D2.C, IC3.16, IC5.1, R31.1
VCC_RC: 1.VCC, 2.VCC, 3.VCC, D2.A, ST.VCC, TH.VCC
VCC_RC1: C15.2, C24.2, IC5.5, R11.2, R18.2

## EAGLE design 0612_jetracer/PCB/612_jetracer_328_214.brd

Schematic: 612_jetracer_328_214.sch

Parts:
1, 2, 3: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
C1, C3, C20, C24: 0.1uF; 0603
C2, C8, C9, C11, C12: 10uF; 0603
C4, C5, C6, C7, C10: 1uF; 0603
C22: 4.7uF; 0603
C23: 0.01uF; 0603
CN1: PIN_1X3
D1: 1N4148; 1N4148W
D2, D3, D4, D5: 1N4148W; SOD3715X135
IC1: ATMEGA328P-AU; TQFP-32
IC2: JETSON_NANO_NOBORDER; JETSON_NANO_NOBOARDER
IC3: MULTIPLEXERSMC74HC157A; TSSOP-16
IC4: PCA9685
IC5: LP2985-33DBV; SOT-23-5
ICSP1: ICSP_AVR-TC_NOHOLE; TC2030
JETSON: GREEN; 0603
JETSON1: RED; 0603
JP2: JUMPER-SMT_3_1-NC_TRACE_SILK; SMT-JUMPER_3_1-NC_TRACE_SILK
M1, M2, M3, M4, M5, M6: MOSFET-N_FDN335N; SUPERSOT-3
Q1, Q2: MOSFET-N_FDN335N; SUPERSOT-3
R1, R2, R3, R7, R9, R14, R16, R19, R22, R23: 10K; 0603
R4, R6, R10, R12, R13, R15, R21, R26, R30: 1K; 0603
R5: 470; 0603
R8, R28, R37, R39: 100; 0603
R11, R18: 5.1K; 0603
R17, R20: 47; 0603
R24, R27, R31: 4.7K; 0603
R25, R29, R32: 330; 0603
R33, R34: 220; 0603
R35: 390K; 0603
R36, R38, R40: 100K; 0603
R41: DNP; 0603
SPI-LED: FABO-SPI-LED-B04B; SPI-B04B-PASK-1
ST: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
SW1: TACT-SWITCH-SMD_KMR2; KMR2
TH: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
U1: ER-OLED0.96-1ER-CON30HT-1; ER-CON30HT-1
U$14, U$20, U$23: SN74LVC1G17; SOT-23
X2: 16MHz; CSTNE_V_C

Connections:
3V3: C2.2, C3.2, C6.2, C7.2, C12.2, C20.2, C24.2, D1.CATHODE, IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), IC2.1 (3V3), IC2.17 (3V3), IC3.16 (VCC), IC4.28 (VDD), ICSP1.2, JP2.1, R2.2, R7.1, R9.1, R11.2, R18.2, R22.1, R23.1, R41.2, U1.22 (VDD), U1.25 (VBAT)
5V: IC2.2 (5V), SPI-LED.VCC
AVR_MISO: IC1.16 (PB4(MISO)), ICSP1.1
AVR_MOSI: IC1.15 (PB3(MOSI/OC2)), ICSP1.4, SPI-LED.DI
AVR_RESET: IC1.29 (PC6(/RESET)), ICSP1.5, R2.1
AVR_RX: IC1.30 (PD0(RXD)), R12.2
AVR_SCK: IC1.17 (PB5(SCK)), ICSP1.3, SPI-LED.CI
AVR_TX: IC1.31 (PD1(TXD)), R13.2
CE0: IC2.24 (CE0)
CH1: IC1.23 (PC0(ADC0)), IC3.2 (A0), R29.2
CH2: IC1.24 (PC1(ADC1)), IC3.5 (A1), R25.2
CH3: IC1.26 (PC3(ADC3)), R32.2
D3: IC1.1 (PD3(INT1)), JETSON1.ANODE
D4: IC1.2 (PD4(XCK/T0)), JETSON.ANODE
GND: 1.GND, 2.GND, 3.GND, C1.1, C2.1, C3.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C20.1, C22.1, C23.1, C24.1, CN1.3, IC1.3 (GND), IC1.5 (AGND), IC1.21 (GND), IC2.9 (GND), IC2.14 (GND), IC2.20 (GND), IC2.25 (GND), IC2.30 (GND), IC2.34 (GND), IC2.39 (GND), IC3.8 (GND), IC3.15 (EN), IC4.1 (A0), IC4.2 (A1), IC4.3 (A2), IC4.4 (A3), IC4.5 (A4), IC4.14 (VSS), IC4.24 (A5), IC5.2 (GND), ICSP1.6, M1.S, M2.S, M3.S, M4.S, M5.S, M6.S, R1.1, R3.1, R5.1, R10.1, R16.1, R24.1, R27.1, R31.1, R35.2, R36.2, R38.2, R40.2, SPI-LED.GND, ST.GND, SW1.1, SW1.2, TH.GND, U1.2 (VLSS), U1.6 (D7), U1.7 (D6), U1.8 (D5), U1.9 (D4), U1.10 (D3), U1.14 (E/RD#), U1.15 (R/W#), U1.16 (D/C#), U1.18 (CS#), U1.19 (BS2), U1.21 (BS0), U1.23 (VSS), U$14.3 (GND), U$20.3 (GND), U$23.3 (GND), X2.2
GPIO4: IC2.7 (GPIO4)
GPIO5: IC2.29 (GPIO5)
GPIO6: IC2.31 (GPIO6)
GPIO12: IC2.32 (GPIO12)
GPIO13: IC2.33 (GPIO13)
GPIO16: IC2.36 (GPIO16)
GPIO17: IC2.11 (GPIO17)
GPIO18: IC2.12 (GPIO18)
GPIO19: IC2.35 (GPIO19)
GPIO20: IC2.38 (GPIO20)
GPIO21: IC2.40 (GPIO21)
GPIO22: IC2.15 (GPIO22)
GPIO23: IC2.16 (GPIO23)
GPIO24: IC2.18 (GPIO24)
GPIO25: IC2.22 (GPIO25)
GPIO26: IC2.37 (GPIO26)
GPIO27: IC2.13 (GPIO27)
J_CH1: IC3.3 (B0), R33.1
J_CH2: IC3.6 (B1), R34.1
MISO: IC2.21 (MISO)
MOSI: IC2.19 (MOSI)
unnamed: M1.G, R28.1, R36.1
unnamed: Q1.D, R17.2, R19.1
unnamed: C1.2, IC1.20 (AREF)
unnamed: IC1.8 (PB7(XTAL2/TOSC2)), X2.3
unnamed: CN1.1, R12.1
unnamed: IC1.19 (ADC6), R41.1, SW1.3, SW1.4
unnamed: IC4.25 (EXTCLK), R1.2
unnamed: Q2.D, R14.1, R20.2
unnamed: R17.1, ST.I/O
unnamed: M1.D, M2.G, R4.1
unnamed: D3.2 (A), M2.D, R6.1
unnamed: 2.I/O, R37.2
unnamed: R20.1, TH.I/O
unnamed: IC1.7 (PB6(XTAL1/TOSC1)), X2.1
unnamed: C4.2, U1.27 (C1P)
unnamed: CN1.2, R13.1
unnamed: M3.D, M4.G, R15.1
unnamed: JETSON1.CATHODE, R5.2
unnamed: JETSON.CATHODE, R10.2
unnamed: C4.1, U1.26 (C1N)
unnamed: C5.1, U1.28 (C2N)
unnamed: C5.2, U1.29 (C2P)
unnamed: R35.1, U1.5 (IREF)
unnamed: C9.2, U1.4 (VCOMH)
unnamed: C8.2, U1.3 (VCC)
unnamed: R8.2, U1.17 (RES#)
unnamed: C11.2, D1.ANODE, R8.1, R23.2
unnamed: D2.2 (A), M4.D, R21.1
unnamed: D2.1 (C), R24.2, U$20.2 (A)
unnamed: R25.1, U$20.4 (Y)
unnamed: 3.I/O, R39.2
unnamed: M5.D, M6.G, R26.1
unnamed: D3.1 (C), R27.2, U$14.2 (A)
unnamed: R29.1, U$14.4 (Y)
unnamed: D4.2 (A), M6.D, R30.1
unnamed: D4.1 (C), R31.2, U$23.2 (A)
unnamed: R32.1, U$23.4 (Y)
unnamed: Q2.G, R11.1
unnamed: Q1.G, R18.1
unnamed: JP2.2, R14.2, R19.2
unnamed: IC4.6 (LED0), R33.2
unnamed: IC4.7 (LED1), R34.2
unnamed: 1.I/O, R28.2
unnamed: M3.G, R37.1, R38.1
unnamed: M5.G, R39.1, R40.1
unnamed: C23.2, IC5.4 (BYPASS)
unnamed: C10.2, D5.1 (C), IC5.1 (VIN), IC5.3 (ON/OFF)
unnamed: R22.2, U1.20 (BS1)
NC0: IC2.4 (5V)
NC1: IC2.6 (GND)
OE_PIN: IC1.22 (ADC7), IC4.23 (OE), R3.2
RCH1: IC3.4 (Y0), Q1.S
RCH2: IC3.7 (Y1), Q2.S
RC_3V3: C22.2, IC5.5 (VOUT), U$14.5 (VCC), U$20.5 (VCC), U$23.5 (VCC)
RX: IC2.10 (RX)
SCL: IC1.28 (PC5(ADC5/SCL)), IC2.5 (SCL), IC4.26 (SCL), R7.2, U1.13 (D0)
SCLK: IC2.23 (SCLK)
SDA: IC1.27 (PC4(ADC4/SDA)), IC2.3 (SDA), IC4.27 (SDA), R9.2, U1.11 (D2), U1.12 (D1)
SEL: IC1.32 (PD2(INT0)), IC3.1 (SEL), R16.2
TX: IC2.8 (TX)
VCC_RC: 1.VCC, 2.VCC, 3.VCC, D5.2 (A), JP2.3, R4.2, R6.2, R15.2, R21.2, R26.2, R30.2, ST.VCC, TH.VCC

Notes on the sheet:
2.0.14
Jetson Nano
PWM Controller
Address 0x40
MULTIPLEXERS
D11
D12
D13
Arduino
Serial
ICSP
1N4148
OLED
*Signal to the car body
steering
throttle
OUT(TO SERVO,ESC)
SPI_LED
MC74HC157A
ＡＴＭＥＧＡ３２８Ｐ－ＡＵ
SN74LVC1G17
INPUT 1
INPUT 2
INPUT 3
OUTPUT 1,2
PWM OUTPUT
REVISION
SELECTOR
2021/10/28 Rev 2.0.14 ボディ装着のため、基板レイアウト変更,RC電源のみで走行可能、プロポマルチ対応,RC GND共通化
Analog 3V3
受信機から入力
ESC
サーボ
RC +B

Board: 2 copper layers, 67.0 x 33.4 mm, 98 parts (38 on the bottom side), 72 nets.

Other parts of the board:
U$1, U$2, U$3, U$6: MARK_POINT_3MM
U$4: LOGO_FABO_L_BOTTOM
U$24: LOGO_FABO_S

## EAGLE design 0612_jetracer/PCB/612_jetracer_328_300.brd

Schematic: 612_jetracer_328_300.sch

Parts:
1, 2, 3: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
16, 22, 26, 27: TESTPAD_TPSQTP20R; TESTPAD_TP20R
C1, C3, C16, C17, C18: 0.1uF; 0603
C2, C8, C9, C11: 10uF; 0603
C4, C5, C6, C7, C10: 1uF; 0603
C22: 4.7uF; 0603
C23: 0.01uF; 0603
D1: 1N4148; 1N4148W
D2, D3, D6: DIODE-SOD-323; SOD-323
D5: 1N4148W; SOD3715X135
D10: PMEG2010ER; SOD123W
I2C: FABO-I2C_BM04B; I2C-BM04B-PASS-1
IC2: JETSON_NANO_NOBORDER; JETSON_NANO_NOBOARDER
IC3: MULTIPLEXERSMC74HC157A; TSSOP-16
IC4: PCA9685
IC5: LP2985-33DBV; SOT-23-5
J1, J2: CONN_03SMD_RA_MALE; 1X03_SMD_RA_MALE
JETSON: GREEN; 0603
JETSON1: RED; 0603
JP2: JUMPER-SMT_3_1-NC_TRACE_SILK; SMT-JUMPER_3_1-NC_TRACE_SILK
LED-SPI: FABO-SPI-LED-BM04B; SPI-BM04B-PASS-1
R1, R3, R7, R9, R13, R14, R16, R19, R22, R23, R36, R47, R48, R49, R50: 10K; 0603
R2, R12, R33, R34, R45: 220; 0603
R4, R6, R15, R21, R26, R53: 1K/0402; 0402
R5: 470; 0603
R8: 100; 0603
R10, R42: 1K; 0603
R11, R18, R43, R44, R51: 0; 0603
R17, R20: 47; 0603
R24, R27, R31: 4.7K/0402; 0402
R25, R29, R32: 330; 0603
R28, R30, R37: 100/0402; 0402
R35: 390K; 0603
R38, R39, R40: 100K/0402; 0402
R41: DNP; 0603
R46: 4.7K; 0603
R52: DNF; 0603
RC_3V3: TESTPAD_TPSQTP20R; TESTPAD_TP20R
RC_PWR: ORANGE; 0603
ST: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
SW1: TACT-SWITCH-SMD_KMR2; KMR2
T2: TRANSISTOR-NPN; SOT-23
TH: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
TP1: TESTPAD_TPSQTP20R; TESTPAD_TP20R
U1: ER-OLED0.96-1ER-CON30HT-1; ER-CON30HT-1
U2: RASPBERRY_PI_PICO; RASPBERRY_PI_PICO_SMD
U3, U7: TLP291A; 11-3C1
U$5, U$8: TLP2270
U$9, U$11, U$21: SSM6N7002KFU; US6
U$14, U$20, U$23: SN74LVC1G17; SOT-23
U$27, U$28: T2N7002AK; SOT-23

Connections:
0: C1.1, R36.2
3V3: C2.2, C6.2, C7.2, C16.2, C18.2, D1.CATHODE, IC2.1 (3V3), IC2.17 (3V3), IC4.28 (VDD), R7.1, R9.1, R22.1, R23.1, R41.2, U1.22 (VDD), U1.25 (VBAT), U7.4 (COL), U$8.8 (8:VDD_)
5V: D10.2 (ANODE), I2C.5V (VCC), IC2.2 (5V), LED-SPI.5V (VCC), R12.1, TP1.TP
CE0: IC2.24 (CE0)
CH1: IC3.2 (A0), R29.2, R43.2
CH2: IC3.5 (A1), R25.2, R44.2
CH3: R32.2, R45.2
D3: JETSON1.ANODE, U2.14 (GP10)
D4: JETSON.ANODE, U2.15 (GP11)
EN: R36.1, R52.2, U3.3 (EMI)
GND: C2.1, C6.1, C7.1, C8.1, C9.1, C11.1, C16.1, C18.1, I2C.GND, IC2.9 (GND), IC2.14 (GND), IC2.20 (GND), IC2.25 (GND), IC2.30 (GND), IC2.34 (GND), IC2.39 (GND), IC4.1 (A0), IC4.2 (A1), IC4.3 (A2), IC4.4 (A3), IC4.5 (A4), IC4.14 (VSS), IC4.24 (A5), J1.1, J2.2, LED-SPI.GND, R1.1, R3.1, R5.1, R10.1, R13.2, R35.2, R46.1, R47.2, R48.2, SW1.1, SW1.2, T2.2 (E), U1.2 (VLSS), U1.6 (D7), U1.7 (D6), U1.8 (D5), U1.9 (D4), U1.10 (D3), U1.14 (E/RD#), U1.15 (R/W#), U1.16 (D/C#), U1.18 (CS#), U1.19 (BS2), U1.21 (BS0), U1.23 (VSS), U2.8 (GND), U2.13 (GND), U2.18 (GND), U2.23 (GND), U2.28 (GND), U2.38 (GND), U2.D2 (GND), U$5.2 (2:CA1), U$5.3 (3:CA2), U$8.5 (5:GND)
GPIO4: IC2.7 (GPIO4)
GPIO5: IC2.29 (GPIO5)
GPIO6: IC2.31 (GPIO6)
GPIO12: IC2.32 (GPIO12)
GPIO13: IC2.33 (GPIO13)
GPIO16: IC2.36 (GPIO16)
GPIO17: IC2.11 (GPIO17)
GPIO18: IC2.12 (GPIO18)
GPIO19: IC2.35 (GPIO19)
GPIO20: IC2.38 (GPIO20)
GPIO21: IC2.40 (GPIO21)
GPIO22: IC2.15 (GPIO22)
GPIO23: IC2.16 (GPIO23)
GPIO24: IC2.18 (GPIO24)
GPIO25: IC2.22 (GPIO25)
GPIO26: IC2.37 (GPIO26)
GPIO27: IC2.13 (GPIO27)
J_CH1: IC3.3 (B0), U$5.7 (7:OUT1)
J_CH2: IC3.6 (B1), U$5.6 (6:OUT2)
LED_MOSI: LED-SPI.DI, U2.25 (GP19)
LED_SCK: LED-SPI.CI, U2.24 (GP18)
MISO: IC2.21 (MISO)
MOSI: IC2.19 (MOSI)
unnamed: R28.2, R38.2, U$9.2 (2:GATE1)
unnamed: R14.1, R20.2, U$27.3 (3:DRAIN)
unnamed: D10.1 (CATHODE), U2.39 (VSYS)
unnamed: 22.TP, U2.29 (GP22)
unnamed: R2.1, U2.17 (GP13)
unnamed: R41.1, SW1.3, SW1.4, U2.34 (GP28)
unnamed: IC4.25 (EXTCLK), R1.2
unnamed: R11.1, U$27.1 (1:GATE)
unnamed: R17.1, ST.I/O
unnamed: R30.2, R40.2, U$11.2 (2:GATE1)
unnamed: D3.A (ANODE), R6.1, U$9.3 (3:DRAIN2)
unnamed: 2.I/O, R30.1
unnamed: R20.1, TH.I/O
unnamed: 26.TP, U2.31 (GP26)
unnamed: C4.2, U1.27 (C1P)
unnamed: R18.1, U$28.1 (1:GATE)
unnamed: R15.1, U$11.5 (5:GATE2), U$11.6 (6:DRAIN1)
unnamed: JETSON1.CATHODE, R5.2
unnamed: JETSON.CATHODE, R10.2
unnamed: C4.1, U1.26 (C1N)
unnamed: C5.1, U1.28 (C2N)
unnamed: C5.2, U1.29 (C2P)
unnamed: R35.1, U1.5 (IREF)
unnamed: C9.2, U1.4 (VCOMH)
unnamed: C8.2, U1.3 (VCC)
unnamed: R8.2, U1.17 (RES#)
unnamed: C11.2, D1.ANODE, R8.1, R23.2
unnamed: D6.A (ANODE), R21.1, U$11.3 (3:DRAIN2)
unnamed: D6.K (CATHODE), R24.2, U$20.2 (A)
unnamed: R25.1, U$20.4 (Y)
unnamed: 3.I/O, R37.1
unnamed: R53.1, U$21.5 (5:GATE2), U$21.6 (6:DRAIN1)
unnamed: D3.K (CATHODE), R27.2, U$14.2 (A)
unnamed: R29.1, U$14.4 (Y)
unnamed: D2.A (ANODE), R26.1, U$21.3 (3:DRAIN2)
unnamed: D2.K (CATHODE), R31.2, U$23.2 (A)
unnamed: R32.1, U$23.4 (Y)
unnamed: R17.2, R19.1, U$28.3 (3:DRAIN)
unnamed: 27.TP, U2.32 (GP27)
unnamed: JP2.2, R14.2, R19.2
unnamed: IC4.6 (LED0), R33.2
unnamed: IC4.7 (LED1), R34.2
unnamed: 1.I/O, R28.1
unnamed: IC3.15 (EN), R51.2, R52.1
unnamed: R37.2, R39.2, U$21.2 (2:GATE1)
unnamed: C23.2, IC5.4 (BYPASS)
unnamed: C10.2, D5.1 (C), IC5.1 (VIN), IC5.3 (ON/OFF)
unnamed: R42.2, RC_PWR.CATHODE
unnamed: R22.2, U1.20 (BS1)
unnamed: 16.TP, U2.21 (GP16)
unnamed: J2.3, U2.D1 (SWCLK)
unnamed: R33.1, R47.1, U$5.1 (1:AN1)
unnamed: R34.1, R48.1, U$5.4 (4:AN2)
unnamed: U2.20 (GP15), U$8.7 (7:OUT1)
unnamed: U2.19 (GP14), U$8.6 (6:OUT2)
unnamed: R43.1, R49.2, U$8.1 (1:AN1)
unnamed: R44.1, R50.2, U$8.4 (4:AN2)
unnamed: R45.1, U7.1 (A)
unnamed: R46.2, U2.6 (GP4), U7.3 (EMI)
unnamed: R4.1, U$9.5 (5:GATE2), U$9.6 (6:DRAIN1)
unnamed: T2.3 (C), U3.2 (C)
unnamed: R12.2, U3.1 (A)
unnamed: R2.2, R13.1, T2.1 (B)
unnamed: J2.1, U2.D3 (SWDIO)
NC: U2.3 (GND)
NC0: IC2.4 (5V)
NC1: IC2.6 (GND)
OE_PIN: IC4.23 (OE), R3.2, U2.10 (GP7)
PICO_RX: J1.2, U2.2 (GP1)
PICO_TX: J1.3, U2.1 (GP0)
RCH1: IC3.4 (Y0), U$28.2 (2:SOURCE)
RCH2: IC3.7 (Y1), U$27.2 (2:SOURCE)
RC_+B_3V3: C1.2, C3.2, C17.2, C22.2, IC3.16 (VCC), IC5.5 (VOUT), JP2.1, R11.2, R18.2, RC_3V3.TP, U3.4 (COL), U$5.8 (8:VDD_), U$14.5 (VCC), U$20.5 (VCC), U$23.5 (VCC)
RC_GND: 1.GND, 2.GND, 3.GND, C3.1, C10.1, C17.1, C22.1, C23.1, IC3.8 (GND), IC5.2 (GND), R16.1, R24.1, R27.1, R31.1, R38.1, R39.1, R40.1, R42.1, R49.1, R50.1, R51.1, ST.GND, TH.GND, U7.2 (C), U$5.5 (5:GND), U$8.2 (2:CA1), U$8.3 (3:CA2), U$9.1 (1:SOURCE1), U$9.4 (4:SOURCE2), U$11.1 (1:SOURCE1), U$11.4 (4:SOURCE2), U$14.3 (GND), U$20.3 (GND), U$21.1 (1:SOURCE1), U$21.4 (4:SOURCE2), U$23.3 (GND)
RX: IC2.10 (RX)
SCL: I2C.SCL, IC2.5 (SCL), IC4.26 (SCL), R7.2, U1.13 (D0), U2.12 (GP9)
SCLK: IC2.23 (SCLK)
SDA: I2C.SDA, IC2.3 (SDA), IC4.27 (SDA), R9.2, U1.11 (D2), U1.12 (D1), U2.11 (GP8)
SEL: IC3.1 (SEL), R16.2, U2.16 (GP12)
TX: IC2.8 (TX)
VCC_RC: 1.VCC, 2.VCC, 3.VCC, D5.2 (A), JP2.3, R4.2, R6.2, R15.2, R21.2, R26.2, R53.2, RC_PWR.ANODE, ST.VCC, TH.VCC

Notes on the sheet:
2.0.15
Jetson Nano
PWM Controller
Address 0x40
MULTIPLEXERS
Serial
1N4148
OLED
*Signal to the car body
steering
throttle
OUT(TO SERVO,ESC)
SPI_LED
MC74HC157A
SN74LVC1G17
INPUT 1
INPUT 2
INPUT 3
OUTPUT 1,2
PWM OUTPUT
REVISION
SELECTOR CONTROL
2021/10/28 Rev 2.0.14 ボディ装着のため、基板レイアウト変更,RC電源のみで走行可能、プロポマルチ対応,RC GND共通化
LDO 3V3
受信機から入力
ESC
サーボ
RC +B
2021/10/29 Rev 2.0.15 絶縁化
RC_AREA
Jetson AREA
I2C
2021/11/11 Rev 3.0.0 328PからPICOへ変更,MOS-FETを変更
T2N7002AK

Board: 2 copper layers, 75.5 x 50.0 mm, 120 parts (66 on the bottom side), 89 nets.

Other parts of the board:
U$1, U$2, U$3, U$29: MARK_POINT_3MM
U$4: LOGO_FABO_L_BOTTOM
U$30: LOGO_FABO_L

## EAGLE design 0612_jetracer/PCB/612_jetracer_328_nodisplay.brd

Parts:
C1, C2, C3: 0.1uF; 0603
CH1, CH2, CH3: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
DEBUG: FABO_BRICK_3PIN_DEBUG
IC1: ATMEGA328P-AU; TQFP-32
IC3: MULTIPLEXERSMC74HC157A; TSSOP-16
ICSP1: ICSP_AVR-TC_NOHOLE; TC2030
JETSON: GREEN; 0603
LOGO1: LOGO_FABO-S; LOGO_FABO_S
R1, R4: 10k; EXBV8V
R2: 10K; 0603
R3: 220; EXBV8V
R5, R10: 10k; 0603
R6: 75K; 0603
RC: RED; 0603
SPI-LED: FABO-SPI-LED-B04B; SPI-B04B-PASK-1
ST: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
TH: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
U$2: JETSON_NANO_NOBORDER; JETSON_NANO_NOBOARDER
U$3: PCA9685
U$5: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
X2: 16MHz; CSTNE_V_C

Connections:
3V3: C2.2, C3.2, IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), IC3.16 (VCC), ICSP1.2, R2.2, U$2.1 (3V3), U$3.28 (VDD)
5V: SPI-LED.VCC, U$2.2 (5V)
AVR_MISO: IC1.16 (PB4(MISO)), ICSP1.1
AVR_MOSI: IC1.15 (PB3(MOSI/OC2)), ICSP1.4, SPI-LED.DI
AVR_RESET: IC1.29 (PC6(/RESET)), ICSP1.5, R2.1
AVR_RX: DEBUG.RX, IC1.30 (PD0(RXD))
AVR_SCK: IC1.17 (PB5(SCK)), ICSP1.3, SPI-LED.CI
AVR_TX: DEBUG.TX, IC1.31 (PD1(TXD))
CE0: U$2.24 (CE0)
D2: IC1.32 (PD2(INT0)), IC3.1 (SEL)
D3: IC1.1 (PD3(INT1)), R5.1
D4: IC1.2 (PD4(XCK/T0)), R10.1
D5: IC1.9 (PD5(T1))
D6: IC1.10 (PD6(AIN0))
D7: IC1.11 (PD7(AIN1))
D8: IC1.12 (PB0(ICP))
D9: IC1.13 (PB1(OC1A))
D10: IC1.14 (PB2(SS/OC1B))
GND: C1.1, C2.1, C3.1, CH1.GND, CH2.GND, CH3.GND, DEBUG.GND, IC1.3 (GND), IC1.5 (AGND), IC1.21 (GND), IC3.8 (GND), IC3.15 (EN), ICSP1.6, JETSON.CATHODE, R1.1, R1.2 (1), R1.3 (1), R1.4 (1), R4.1, R4.2 (1), R4.3 (1), R4.4 (1), R6.1, RC.CATHODE, SPI-LED.GND, ST.GND, TH.GND, U$2.6 (GND), U$2.9 (GND), U$2.14 (GND), U$2.20 (GND), U$2.25 (GND), U$2.30 (GND), U$2.34 (GND), U$2.39 (GND), U$3.14 (VSS), X2.2
GPIO4: U$2.7 (GPIO4)
GPIO5: U$2.29 (GPIO5)
GPIO6: U$2.31 (GPIO6)
GPIO12: U$2.32 (GPIO12)
GPIO13: U$2.33 (GPIO13)
GPIO16: U$2.36 (GPIO16)
GPIO17: U$2.11 (GPIO17)
GPIO18: U$2.12 (GPIO18)
GPIO19: U$2.35 (GPIO19)
GPIO20: U$2.38 (GPIO20)
GPIO21: U$2.40 (GPIO21)
GPIO22: U$2.15 (GPIO22)
GPIO23: U$2.16 (GPIO23)
GPIO24: U$2.18 (GPIO24)
GPIO25: U$2.22 (GPIO25)
GPIO26: U$2.37 (GPIO26)
GPIO27: U$2.13 (GPIO27)
MISO: U$2.21 (MISO)
MOSI: U$2.19 (MOSI)
unnamed: R3.1, U$3.6 (LED0)
unnamed: R3.2 (1), U$3.7 (LED1)
unnamed: C1.2, IC1.20 (AREF)
unnamed: IC1.8 (PB7(XTAL2/TOSC2)), X2.3
unnamed: R4.5 (2), U$3.23 (OE)
unnamed: R1.8 (2), U$3.25 (EXTCLK)
unnamed: R1.7 (2), U$3.1 (A0)
unnamed: R1.6 (2), U$3.2 (A1)
unnamed: R1.5 (2), U$3.3 (A2)
unnamed: R4.8 (2), U$3.4 (A3)
unnamed: R4.7 (2), U$3.5 (A4)
unnamed: R4.6 (2), U$3.24 (A5)
unnamed: IC1.7 (PB6(XTAL1/TOSC1)), X2.1
unnamed: R5.2, RC.ANODE
unnamed: JETSON.ANODE, R10.2
PCH1: CH1.I/O, IC1.23 (PC0(ADC0)), IC3.2 (A0)
PCH2: CH2.I/O, IC1.24 (PC1(ADC1)), IC3.5 (A1)
PCH3: IC1.25 (PC2(ADC2))
PWM0: IC3.3 (B0), R3.8 (2)
PWM1: IC3.6 (B1), R3.7 (2)
RCH1: IC3.4 (Y0), ST.I/O
RCH2: IC3.7 (Y1), TH.I/O
RX: U$2.10 (RX)
SCL: IC1.28 (PC5(ADC5/SCL)), U$2.5 (SCL), U$3.26 (SCL)
SCLK: U$2.23 (SCLK)
SDA: IC1.27 (PC4(ADC4/SDA)), U$2.3 (SDA), U$3.27 (SDA)
SEL: CH3.I/O, IC1.26 (PC3(ADC3)), R6.2
TX: U$2.8 (TX)
VCC: CH1.VCC, CH2.VCC, CH3.VCC, ST.VCC, TH.VCC

Notes on the sheet:
1.0.8
Jetson Nano
PWM Controller
MULTIPLEXERS
Address 0x60
PIN HEADER
D11
D12
D13
Arduino
Serial
ICSP

Board: 2 copper layers, 77.6 x 18.4 mm, 29 parts (0 on the bottom side), 37 nets.

Other parts of the board:
U$4, U$6: MARK_POINT_3MM

Notices in the files:
parts and their libraries:
FaBo-etc: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
SparkFun-Jumpers: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
FaBo-etc: Released under the Creative Commons
