# Repository FaBoPlatform/FaBo (continued)

## EAGLE design 0612_jetracer/PCB/612_jetracer_pico_300.brd

Schematic: 612_jetracer_pico_300.sch

Parts:
1, 2, 3: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
16, 22, 26, 27: TESTPAD_TPSQTP20R; TESTPAD_TP20R
C1, C3, C12, C16, C17, C18: 0.1uF; 0603
C2, C8, C9, C11: 10uF; 0603
C4, C5, C6, C7, C10: 1uF; 0603
C22: 4.7uF; 0603
C23: 0.01uF; 0603
D1: 1N4148; 1N4148W
D2, D3, D6: DIODE-SOD-323; SOD-323
D5: 1N4148W; SOD3715X135
D10: PMEG2010ER; SOD123W
I2C: FABO-I2C_BM04B; I2C-BM04B-PASS-1
IC2: JETSON_NANO_NOBORDER; JETSON_NANO_NOBOARDER
IC3: MULTIPLEXERSMC74HC157A; TSSOP-16
IC4: PCA9685
IC5: LP2985-33DBV; SOT-23-5
J1, J2: CONN_03SMD_RA_MALE; 1X03_SMD_RA_MALE
JETSON: GREEN; 0603
JETSON1: RED; 0603
JP2: JUMPER-SMT_3_1-NC_TRACE_SILK; SMT-JUMPER_3_1-NC_TRACE_SILK
LED-SPI: FABO-SPI-LED-BM04B; SPI-BM04B-PASS-1
R1, R3, R7, R9, R13, R14, R16, R19, R22, R23, R36, R47, R48, R49, R50, R59, R60: 10K; 0603
R2, R12, R45, R57, R58: 220; 0603
R4, R6, R15, R21, R26, R53: 1K/0402; 0402
R5: 470; 0603
R8: 100; 0603
R10, R42: 1K; 0603
R11, R18, R25, R29, R32, R51: 0; 0603
R17, R20: 47; 0603
R24, R27, R31, R54, R55, R56: 4.7K/0402; 0402
R28, R30, R37: 100/0402; 0402
R33, R34, R43, R44: 330; 0603
R35: 390K; 0603
R38, R39, R40: 100K/0402; 0402
R41: DNP; 0603
R46: 4.7K; 0603
R52: DNF; 0603
RC_3V3: TESTPAD_TPSQTP20R; TESTPAD_TP20R
RC_PWR: ORANGE; 0603
ST: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
SW1: TACT-SWITCH-SMD_KMR2; KMR2
T1, T2: TRANSISTOR-NPN; SOT-23
TH: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
TP1: TESTPAD_TPSQTP20R; TESTPAD_TP20R
U1: ER-OLED0.96-1ER-CON30HT-1; ER-CON30HT-1
U2: RASPBERRY_PI_PICO; RASPBERRY_PI_PICO_SMD
U3, U4, U7: TLP291A; 11-3C1
U$5, U$8: TLP2270
U$9, U$11, U$21: SSM6N7002KFU; US6
U$14, U$20, U$23: SN74LVC1G17; SOT-23
U$27, U$28: T2N7002AK; SOT-23

Connections:
3V3: C2.2, C6.2, C7.2, C16.2, C18.2, D1.CATHODE, IC2.1 (3V3), IC2.17 (3V3), IC4.28 (VDD), R7.1, R9.1, R22.1, R23.1, R41.2, U1.22 (VDD), U1.25 (VBAT), U7.4 (COL), U$8.8 (8:VDD_)
5V: D10.2 (ANODE), I2C.5V (VCC), IC2.2 (5V), LED-SPI.5V (VCC), TP1.TP
CE0: IC2.24 (CE0)
CH1: IC3.2 (A0), R29.2, R43.2
CH2: IC3.5 (A1), R25.2, R44.2
CH3: R32.2, R45.2
D3: JETSON1.ANODE, U2.14 (GP10)
D4: JETSON.ANODE, U2.15 (GP11)
EN: R36.1, R52.2, U3.3 (EMI)
GND: C2.1, C6.1, C7.1, C8.1, C9.1, C11.1, C16.1, C18.1, I2C.GND, IC2.9 (GND), IC2.14 (GND), IC2.20 (GND), IC2.25 (GND), IC2.30 (GND), IC2.34 (GND), IC2.39 (GND), IC4.1 (A0), IC4.2 (A1), IC4.3 (A2), IC4.4 (A3), IC4.5 (A4), IC4.14 (VSS), IC4.24 (A5), J1.1, J2.2, LED-SPI.GND, R1.1, R3.1, R5.1, R10.1, R13.2, R35.2, R46.1, R47.2, R48.2, R59.2, SW1.1, SW1.2, T1.2 (E), T2.2 (E), U1.2 (VLSS), U1.6 (D7), U1.7 (D6), U1.8 (D5), U1.9 (D4), U1.10 (D3), U1.14 (E/RD#), U1.15 (R/W#), U1.16 (D/C#), U1.18 (CS#), U1.19 (BS2), U1.21 (BS0), U1.23 (VSS), U2.8 (GND), U2.13 (GND), U2.18 (GND), U2.23 (GND), U2.28 (GND), U2.38 (GND), U2.D2 (GND), U$5.2 (2:CA1), U$5.3 (3:CA2), U$8.5 (5:GND)
GPIO4: IC2.7 (GPIO4)
GPIO5: IC2.29 (GPIO5)
GPIO6: IC2.31 (GPIO6)
GPIO12: IC2.32 (GPIO12)
GPIO13: IC2.33 (GPIO13)
GPIO16: IC2.36 (GPIO16)
GPIO17: IC2.11 (GPIO17)
GPIO18: IC2.12 (GPIO18)
GPIO19: IC2.35 (GPIO19)
GPIO20: IC2.38 (GPIO20)
GPIO21: IC2.40 (GPIO21)
GPIO22: IC2.15 (GPIO22)
GPIO23: IC2.16 (GPIO23)
GPIO24: IC2.18 (GPIO24)
GPIO25: IC2.22 (GPIO25)
GPIO26: IC2.37 (GPIO26)
GPIO27: IC2.13 (GPIO27)
J_CH1: IC3.3 (B0), U$5.7 (7:OUT1)
J_CH2: IC3.6 (B1), U$5.6 (6:OUT2)
LED_MOSI: LED-SPI.DI, U2.25 (GP19)
LED_SCK: LED-SPI.CI, U2.24 (GP18)
MISO: IC2.21 (MISO)
MLITI_SEL: R57.1, U2.16 (GP12)
MOSI: IC2.19 (MOSI)
unnamed: R28.2, R38.2, U$9.2 (2:GATE1)
unnamed: R14.1, R20.2, U$27.3 (3:DRAIN)
unnamed: 22.TP, U2.29 (GP22)
unnamed: R2.1, U2.17 (GP13)
unnamed: R41.1, SW1.3, SW1.4, U2.34 (GP28)
unnamed: IC4.25 (EXTCLK), R1.2
unnamed: R11.1, U$27.1 (1:GATE)
unnamed: R17.1, ST.I/O
unnamed: R30.2, R40.2, U$11.2 (2:GATE1)
unnamed: D3.A (ANODE), R6.1, R54.2, U$9.3 (3:DRAIN2)
unnamed: 2.I/O, R30.1
unnamed: R20.1, TH.I/O
unnamed: 26.TP, U2.31 (GP26)
unnamed: C4.2, U1.27 (C1P)
unnamed: R18.1, U$28.1 (1:GATE)
unnamed: R15.1, U$11.5 (5:GATE2), U$11.6 (6:DRAIN1)
unnamed: JETSON1.CATHODE, R5.2
unnamed: JETSON.CATHODE, R10.2
unnamed: C4.1, U1.26 (C1N)
unnamed: C5.1, U1.28 (C2N)
unnamed: C5.2, U1.29 (C2P)
unnamed: R35.1, U1.5 (IREF)
unnamed: C9.2, U1.4 (VCOMH)
unnamed: C8.2, U1.3 (VCC)
unnamed: R8.2, U1.17 (RES#)
unnamed: C11.2, D1.ANODE, R8.1, R23.2
unnamed: D6.A (ANODE), R21.1, R55.2, U$11.3 (3:DRAIN2)
unnamed: D6.K (CATHODE), R24.2, U$20.2 (A)
unnamed: R25.1, U$20.4 (Y)
unnamed: 3.I/O, R37.1
unnamed: R53.1, U$21.5 (5:GATE2), U$21.6 (6:DRAIN1)
unnamed: D3.K (CATHODE), R27.2, U$14.2 (A)
unnamed: R29.1, U$14.4 (Y)
unnamed: D2.A (ANODE), R26.1, R56.2, U$21.3 (3:DRAIN2)
unnamed: D2.K (CATHODE), R31.2, U$23.2 (A)
unnamed: R32.1, U$23.4 (Y)
unnamed: R17.2, R19.1, U$28.3 (3:DRAIN)
unnamed: 27.TP, U2.32 (GP27)
unnamed: JP2.2, R14.2, R19.2
unnamed: IC4.6 (LED0), R33.2
unnamed: IC4.7 (LED1), R34.2
unnamed: 1.I/O, R28.1
unnamed: IC3.15 (EN), R51.2, R52.1
unnamed: R37.2, R39.2, U$21.2 (2:GATE1)
unnamed: C23.2, IC5.4 (BYPASS)
unnamed: C10.2, D5.1 (C), IC5.1 (VIN), IC5.3 (ON/OFF)
unnamed: R42.2, RC_PWR.CATHODE
unnamed: R22.2, U1.20 (BS1)
unnamed: 16.TP, U2.21 (GP16)
unnamed: J2.3, U2.D1 (SWCLK)
unnamed: R33.1, R47.1, U$5.1 (1:AN1)
unnamed: R34.1, R48.1, U$5.4 (4:AN2)
unnamed: U2.20 (GP15), U$8.7 (7:OUT1)
unnamed: U2.19 (GP14), U$8.6 (6:OUT2)
unnamed: R43.1, R49.2, U$8.1 (1:AN1)
unnamed: R44.1, R50.2, U$8.4 (4:AN2)
unnamed: R45.1, U7.1 (A)
unnamed: R46.2, U2.6 (GP4), U7.3 (EMI)
unnamed: R4.1, U$9.5 (5:GATE2), U$9.6 (6:DRAIN1)
unnamed: T2.3 (C), U3.2 (C)
unnamed: R12.2, U3.1 (A)
unnamed: R2.2, R13.1, T2.1 (B)
unnamed: J2.1, U2.D3 (SWDIO)
unnamed: T1.3 (C), U4.2 (C)
unnamed: R58.2, U4.1 (A)
unnamed: R57.2, R59.1, T1.1 (B)
NC: U2.3 (GND)
NC0: IC2.4 (5V)
NC1: IC2.6 (GND)
OE_PIN: IC4.23 (OE), R3.2, U2.10 (GP7)
PICO_5V: D10.1 (CATHODE), R12.1, R58.1, U2.39 (VSYS)
PICO_RX: J1.2, U2.2 (GP1)
PICO_TX: J1.3, U2.1 (GP0)
RCH1: IC3.4 (Y0), U$28.2 (2:SOURCE)
RCH2: IC3.7 (Y1), U$27.2 (2:SOURCE)
RC_+B_3V3: C1.2, C3.2, C12.2, C17.2, C22.2, IC3.16 (VCC), IC5.5 (VOUT), JP2.1, R11.2, R18.2, RC_3V3.TP, U3.4 (COL), U4.4 (COL), U$5.8 (8:VDD_), U$14.5 (VCC), U$20.5 (VCC), U$23.5 (VCC)
RC_GND: 1.GND, 2.GND, 3.GND, C1.1, C3.1, C10.1, C12.1, C17.1, C22.1, C23.1, IC3.8 (GND), IC5.2 (GND), R16.1, R24.1, R27.1, R31.1, R36.2, R38.1, R39.1, R40.1, R42.1, R49.1, R50.1, R51.1, R54.1, R55.1, R56.1, R60.2, ST.GND, TH.GND, U7.2 (C), U$5.5 (5:GND), U$8.2 (2:CA1), U$8.3 (3:CA2), U$9.1 (1:SOURCE1), U$9.4 (4:SOURCE2), U$11.1 (1:SOURCE1), U$11.4 (4:SOURCE2), U$14.3 (GND), U$20.3 (GND), U$21.1 (1:SOURCE1), U$21.4 (4:SOURCE2), U$23.3 (GND)
RX: IC2.10 (RX)
SCL: I2C.SCL, IC2.5 (SCL), IC4.26 (SCL), R7.2, U1.13 (D0), U2.12 (GP9)
SCLK: IC2.23 (SCLK)
SDA: I2C.SDA, IC2.3 (SDA), IC4.27 (SDA), R9.2, U1.11 (D2), U1.12 (D1), U2.11 (GP8)
SEL: IC3.1 (SEL), R16.2, R60.1, U4.3 (EMI)
TX: IC2.8 (TX)
VCC_RC: 1.VCC, 2.VCC, 3.VCC, D5.2 (A), JP2.3, R4.2, R6.2, R15.2, R21.2, R26.2, R53.2, RC_PWR.ANODE, ST.VCC, TH.VCC

Notes on the sheet:
2.0.15
Jetson Nano
PWM Controller
Address 0x40
MULTIPLEXERS
Serial
1N4148
OLED
*Signal to the car body
steering
throttle
OUT(TO SERVO,ESC)
SPI_LED
MC74HC157A
SN74LVC1G17
INPUT 1
INPUT 2
INPUT 3
OUTPUT 1,2
PWM OUTPUT
REVISION
SELECTOR CONTROL
2021/10/28 Rev 2.0.14 ボディ装着のため、基板レイアウト変更,RC電源のみで走行可能、プロポマルチ対応,RC GND共通化
LDO 3V3
受信機から入力
ESC
サーボ
RC +B
2021/10/29 Rev 2.0.15 絶縁化
RC_AREA
Jetson AREA
I2C
2021/11/11 Rev 3.0.0 328PからPICOへ変更,MOS-FETを変更,EN追加、SEL絶縁修正
T2N7002AK

Board: 2 copper layers, 75.5 x 50.0 mm, 130 parts (75 on the bottom side), 92 nets.

Other parts of the board:
U$1, U$2, U$3, U$29: MARK_POINT_3MM
U$4: LOGO_FABO_L_BOTTOM
U$30: LOGO_FABO_L

## EAGLE design 0613_jetbot_edu/PCB/611_jetbot.brd

Parts:
A1, A2: 47uF; D60
C1, C2: 0.1uF; 0603
C3: 10uF; 0603
C4, C5, C6, C7: 1uF; 0603-BOTTOM
C8, C9, C10: 10uF; 0603-BOTTOM
D1: 1N4148; 1N4148W
IC1: PCA9306_SSOP; 8PIN-SSOP
P1: MF-NSML600-2; 1206
R1, R2: 10k; EXBV8V
R3, R4: 220; EXBV8V
R5: 100; 0603-BOTTOM
R6: 10K; 0603-BOTTOM
R7: 390K; 0603-BOTTOM
R8: 10K; EXBV8V
R9: 200K; 0603
S1: STPS15L30CB; STPS15L30C
U1: ER-OLED0.96-1ER-CON30HT-1; ER-CON30HT-1
U$3: JETSON_NANO
U$5: TB6612
U$6, U$8: ML-1400-S1
U$9: PCA9685
U$14: LOGO_FABO-M; LOGO_FABO_MS
VM_CN: USB-ZX62D; ZX62D-B-5PA8

Connections:
3V3: C4.2, D1.CATHODE, IC1.2 (VREF1), R6.2, R8.5 (2), R8.6 (2), U1.25 (VBAT), U$3.17 (3V3)
5V: C1.2, IC1.8 (EN), R8.7 (2), R8.8 (2), R9.2, U$3.2 (5V), U$5.19 (STBY), U$5.20 (VCC), U$9.24 (A5), U$9.28 (VDD)
CE0: U$3.24 (CE0)
GND: C1.1, C4.1, C5.1, C8.1, C9.1, C10.1, IC1.1 (GND), R1.1, R1.2 (1), R1.3 (1), R1.4 (1), R2.1, R2.2 (1), R2.4 (1), R7.1, U1.2 (VLSS), U1.6 (D7), U1.7 (D6), U1.8 (D5), U1.9 (D4), U1.10 (D3), U1.14 (E/RD#), U1.15 (R/W#), U1.16 (D/C#), U1.18 (CS#), U1.19 (BS2), U1.21 (BS0), U1.23 (VSS), U$3.9 (GND), U$3.14 (GND), U$3.20 (GND), U$3.25 (GND), U$3.30 (GND), U$3.34 (GND), U$3.39 (GND), U$5.18 (GND), U$9.14 (VSS)
GPIO4: U$3.7 (GPIO4)
GPIO5: U$3.29 (GPIO5)
GPIO6: U$3.31 (GPIO6)
GPIO12: U$3.32 (GPIO12)
GPIO13: U$3.33 (GPIO13)
GPIO16: U$3.36 (GPIO16)
GPIO17: U$3.11 (GPIO17)
GPIO18: U$3.12 (GPIO18)
GPIO19: U$3.35 (GPIO19)
GPIO20: U$3.38 (GPIO20)
GPIO21: U$3.40 (GPIO21)
GPIO22: U$3.15 (GPIO22)
GPIO23: U$3.16 (GPIO23)
GPIO24: U$3.18 (GPIO24)
GPIO25: U$3.22 (GPIO25)
GPIO26: U$3.37 (GPIO26)
GPIO27: U$3.13 (GPIO27)
H_SCL: IC1.6 (SCL2), R8.1, U$9.26 (SCL)
H_SDA: IC1.5 (SDA2), R8.2 (1), U$9.27 (SDA)
MISO: U$3.21 (MISO)
MOSI: U$3.19 (MOSI)
M_GND: A1.MINUS (-), A2.MINUS (-), C2.1, C3.1, U$5.3 (PGND1), U$5.4 (PGND1), U$5.9 (PGN2), U$5.10 (PGN2), VM_CN.5 (GND), VM_CN.B1 (GND), VM_CN.B2 (GND), VM_CN.B3 (GND), VM_CN.B4 (GND), VM_CN.T1 (GND), VM_CN.T2 (GND), VM_CN.T3 (GND), VM_CN.T4 (GND), VM_CN.T5 (GND), VM_CN.T6 (GND)
unnamed: R3.1, U$9.15 (LED8)
unnamed: R3.2 (1), U$9.16 (LED9)
unnamed: R3.3 (1), U$9.17 (LED10)
unnamed: R3.4 (1), U$9.18 (LED11)
unnamed: R4.1, U$9.19 (LED12)
unnamed: R2.5 (2), U$9.23 (OE)
unnamed: R1.8 (2), U$9.25 (EXTCLK)
unnamed: R1.7 (2), U$9.1 (A0)
unnamed: R1.6 (2), U$9.2 (A1)
unnamed: R1.5 (2), U$9.3 (A2)
unnamed: R2.8 (2), U$9.4 (A3)
unnamed: R2.7 (2), U$9.5 (A4)
unnamed: C6.2, U1.27 (C1P)
unnamed: R4.2 (1), U$9.20 (LED13)
unnamed: C6.1, U1.26 (C1N)
unnamed: U$5.1 (AO1), U$5.2 (AO1), U$6.LEFT1 (PIN1), U$6.LEFT2 (PIN1)
unnamed: U$5.5 (AO2), U$5.6 (AO2), U$6.RIGHT1 (PIN2), U$6.RIGHT2 (PIN2)
unnamed: C7.1, U1.28 (C2N)
unnamed: U$5.7 (BO2), U$5.8 (BO2), U$8.LEFT1 (PIN1), U$8.LEFT2 (PIN1)
unnamed: C7.2, U1.29 (C2P)
unnamed: U$5.11 (BO1), U$5.12 (BO1), U$8.RIGHT1 (PIN2), U$8.RIGHT2 (PIN2)
unnamed: R7.2, U1.5 (IREF)
unnamed: C8.2, U1.4 (VCOMH)
unnamed: C9.2, U1.3 (VCC)
unnamed: R5.1, U1.17 (RES#), U1.20 (BS1)
unnamed: C10.2, D1.ANODE, R5.2, R6.1
unnamed: C5.2, U1.22 (VDD)
unnamed: IC1.7 (VREF2), R9.1
PTCP1: P1.P$1 (1), VM_CN.1 (VBUS)
PTCP2: P1.P$2 (2), S1.A1, S1.A2
PWM8: R3.8 (2), U$5.23 (PWMA)
PWM9: R3.7 (2), U$5.22 (AIN2)
PWM10: R3.6 (2), U$5.21 (AIN1)
PWM11: R3.5 (2), U$5.17 (BIN1)
PWM12: R4.8 (2), U$5.16 (BIN2)
PWM13: R4.7 (2), U$5.15 (PWMB)
RX: U$3.10 (RX)
SCL: IC1.3 (SCL1), R8.3 (1), U1.13 (D0), U$3.5 (SCL)
SCLK: U$3.23 (SCLK)
SDA: IC1.4 (SDA1), R8.4 (1), U1.11 (D2), U1.12 (D1), U$3.3 (SDA)
TX: U$3.8 (TX)
VCC: A1.PLUS (+), A2.PLUS (+), C2.2, C3.2, S1.K, U$5.13 (VM2), U$5.14 (VM3), U$5.24 (VM1)

Notes on the sheet:
1.0.3
Jetson Nano
PWM Controller
Power
MOTOR DRIVER
Address 0x60
1.0.9 A
1N4148
LEVEL CONVERTER

Board: 2 copper layers, 37 parts (0 on the bottom side), 45 nets, no tracks yet.

Other parts of the board:
U$2, U$4: MARK_POINT_3MM
U$7, U$10: MARK_POINT_3MM_BOTTOM

## EAGLE design 0614_halloween/PCB/224_distance.brd

Parts:
C1: 1uF; 0603
C2: 0.1uF; 0603
C3: 100nF; 0603
C4: 4.7uF; 0603
IC2: LP2985-33DBV; SOT-23-5
IC3: PCA9306GM; XQFN8
J1: FABO_BRICK_I2C-S04B-PASK-2; FABO_BRICK_I2C_S04B-PASK-2
R1, R2: 4.7k; 0603
R3: 200k; 0603
R4, R5: 10k; 0603
U$3: LOGO_FABO-M; LOGO_FABO_MS
VL1: ST-VL53L0XVL53; ST-VL53L0X

Connections:
5V: IC2.1 (VIN), IC2.3 (ON/OFF), J1.VCC, R3.2
+3V3: C1.2, C3.2, C4.2, IC2.5 (VOUT), R1.2, R2.2, R4.2, R5.2, VL1.1 (AVDDVCSEL), VL1.11 (AVDD)
GND: C1.1, C2.1, C3.1, C4.1, IC2.2 (GND), IC3.1 (GND), J1.GND, VL1.2 (AVSSVCSEL), VL1.3 (GND), VL1.4 (GND), VL1.6 (GND), VL1.12 (GND)
unnamed: C2.2, IC3.7 (VREF2), IC3.8 (EN), R3.1
unnamed: R4.1, VL1.5 (XSHUT)
unnamed: R5.1, VL1.7 (GPIO1)
SCL: IC3.3 (SCL1), R1.1, VL1.10 (SCL)
SCL_HV: IC3.6 (SCL2), J1.SCL
SDA: IC3.4 (SDA1), R2.1, VL1.9 (SDA)
SDA_HV: IC3.5 (SDA2), J1.SDA

Notes on the sheet:
1.0.0.Beta

Board: 2 copper layers, 20.3 x 28.0 mm, 15 parts (0 on the bottom side), 10 nets.

Other parts of the board:
U$2: LOGO_OSHW_M_BOTTOM

## EAGLE design 0614_halloween/PCB/614_donkey_halloween.brd

Parts:
C1: 0.1uF; EIA0603
CN1: Raspberry Pi ZERO W; PIN_2X20_NARROW
I2C: FABO-BRICK-I2C_SIDE_SMD_BOSS; SM04B-PASS-1
PCA9685: PCA9685PW,118; TSSOP-28
PWM0, PWM1: FABO-BRICK-3PIN_HEADER; PIN_1X3_NARROW
R5: 220; EXBV8V
U$3: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
U$4: LOGO_FABO-M; LOGO_FABO_MS

Connections:
3V3: C1.2, CN1.17 (3V3), PCA9685.28 (VDD)
5V: CN1.2 (5V), CN1.4 (5V), I2C.3 (VCC); also elsewhere on the board
GND: C1.1, CN1.6 (GND), CN1.9 (GND), CN1.14 (GND), CN1.20 (GND), CN1.25 (GND), CN1.30 (GND), CN1.34 (GND), CN1.39 (GND), I2C.4 (GND), PCA9685.1 (A0), PCA9685.2 (A1), PCA9685.3 (A2), PCA9685.4 (A3), PCA9685.5 (A4), PCA9685.14 (GND), PCA9685.23 (OE), PCA9685.24 (A5), PCA9685.25 (EXTCLK), PWM0.3 (GND), PWM1.3 (GND); also elsewhere on the board
PIN_LED0: PCA9685.6 (LED0), R5.8 (2)
PIN_LED1: PCA9685.7 (LED1), R5.7 (2)
PWM0: PWM0.1 (I/O), R5.1
PWM1: PWM1.1 (I/O), R5.2 (1)
SCL: CN1.5 (GPIO3/SCL1), I2C.1 (SCL), PCA9685.26 (SCL); also elsewhere on the board
SDA: CN1.3 (GPIO2/SDA1), I2C.2 (SDA), PCA9685.27 (SDA); also elsewhere on the board
VCC: PWM0.2 (VCC), PWM1.2 (VCC)

Notes on the sheet:
1.0.1

Parts:
C2: 10uF; 0603
C3: 0.1uF; 0603
IC1: NX-PCAL6408A; NXP-PCAL6408A
J1, J2, J3: FABO_BRICK_I2C-S04B-PASK-2; FABO_BRICK_I2C_S04B-PASK-2
R2, R4: 10k; EXBV8V
R3: 1k; EXBV8V
R9: 0; 0603-NARROW
R11: NC; 0603-NARROW
T1, T2, T3: 2SC3325-Y; SC-59
U1, U2, U3: FDN338P; SOT-23

Connections:
5V: C2.2, C3.2, IC1.14 (VDD1), IC1.15 (VDD2), R2.6 (2), R2.7 (2), R2.8 (2), R4.7 (2), R4.8 (2), R11.2, U1.2 (S), U2.2 (S), U3.2 (S); also elsewhere on the board
ADDRESS: IC1.16 (ADDR), R9.2, R11.1
GND: C2.1, C3.1, IC1.6 (VSS), IC1.17 (VSS), J1.GND, J2.GND, J3.GND, R9.1, T1.1 (E), T2.1 (E), T3.1 (E); also elsewhere on the board
GPIO0: IC1.2 (P0), R3.8 (2)
GPIO1: IC1.3 (P1), R3.7 (2)
GPIO2: IC1.4 (P2), R3.6 (2)
GPIO3: IC1.5 (P3)
GPIO4: IC1.7 (P4)
GPIO5: IC1.8 (P5)
GPIO6: IC1.9 (P6)
GPIO7: IC1.10 (P7)
unnamed: IC1.1 (RESET), R4.2 (1)
unnamed: IC1.11 (INT), R4.1
unnamed: R2.1, T1.3 (C), U1.1 (G)
unnamed: R2.2 (1), T2.3 (C), U2.1 (G)
unnamed: R3.1, T1.2 (B)
unnamed: R3.2 (1), T2.2 (B)
unnamed: R2.3 (1), T3.3 (C), U3.1 (G)
unnamed: R3.3 (1), T3.2 (B)
SCL: IC1.12 (SCL), J1.SCL, J2.SCL, J3.SCL; also elsewhere on the board
SDA: IC1.13 (SDA), J1.SDA, J2.SDA, J3.SDA; also elsewhere on the board
SW1: J1.VCC, U1.3 (D)
SW2: J2.VCC, U2.3 (D)
SW3: J3.VCC, U3.3 (D)

Notes on the sheet:
ADDRESS 0x20
ADDRESS 0x21

Board: 2 copper layers, 65.0 x 56.0 mm, 26 parts (0 on the bottom side), 25 nets.

Notices in the files:
parts and their libraries:
FaBo-etc: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
SparkFun-Jumpers: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
FaBo-etc: Released under the Creative Commons
