# Repository FaBoPlatform/FaBo

## EAGLE design 0612_jetracer/PCB/612_jetracer_328_020019.brd

Schematic: 612_jetracer_328_020019.sch

Parts:
1, 2, 3: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
C1, C3, C12, C13, C16, C17, C18: 0.1uF; 0603
C2: 10uF; 0603
C10: 1uF; 0603
C14: 0.1uF; 0402
C15: 10uF; 0402
C22: 4.7uF; 0603
C23: 0.01uF; 0603
D2, D3, D6: DIODE-SOD-323; SOD-323
D5: 1N4148W; SOD3715X135
I2C: FABO-I2C_BM04B; I2C-BM04B-PASS-1
IC1: ATMEGA328P-AU; TQFP-32
IC2: JETSON_NANO_NOBORDER; JETSON_NANO_NOBOARDER
IC3: MULTIPLEXERSMC74HC157A; TSSOP-16
IC4: PCA9685
IC5: LP2985-33DBV; SOT-23-5
ICSP1: ICSP_AVR-TC_NOHOLE; TC2030
JETSON: GREEN; 0603
JETSON1: RED; 0603
JP2: JUMPER-SMT_3_1-NC_TRACE_SILK; SMT-JUMPER_3_1-NC_TRACE_SILK
LED-SPI: FABO-SPI-LED-BM04B; SPI-BM04B-PASS-1
R1, R3, R13, R14, R16, R19, R36, R47, R48, R49, R50, R59, R60, R61: 10K; 0603
R2, R12, R45, R57, R58: 220; 0603
R4, R6, R15, R21, R26, R53: 1K/0402; 0402
R5, R41, R62: 470; 0603
R10, R42: 1K; 0603
R11, R18, R25, R29, R32, R51: 0; 0603
R17, R20: 47; 0603
R24, R27, R31, R54, R55, R56: 4.7K/0402; 0402
R28, R30, R37: 100/0402; 0402
R33, R34, R43, R44: 330; 0603
R38, R39, R40: 100K/0402; 0402
R46: 4.7K; 0603
R52: DNF; 0603
RC_3V3: TESTPAD_TPSQTP20R; TESTPAD_TP20R
RC_PWR: ORANGE; 0603
ST: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
T1, T2: TRANSISTOR-NPN; SOT-23
TH: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
TP1, TP2: TP-15
U3, U4, U7: TLP291A; 11-3C1
U$5, U$8: TLP2270
U$9, U$11, U$21: SSM6N7002KFU; US6
U$14, U$20, U$23: SN74LVC1G17; SOT-23
U$27, U$28: T2N7002AK; SOT-23
X2: 16MHz; CSTNE_V_C

Connections:
3V3: C2.2, C14.2, C15.2, C16.2, C18.2, IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), IC2.1 (3V3), IC2.17 (3V3), IC4.28 (VDD), ICSP1.2, R61.2, U7.4 (COL), U$8.8 (8:VDD_)
5V: I2C.5V (VCC), IC2.2 (5V), LED-SPI.5V (VCC)
AVR_MISO: ICSP1.1
AVR_MOSI: ICSP1.4
AVR_RESET: IC1.29 (PC6(/RESET)), ICSP1.5, R61.1
AVR_SCK: ICSP1.3
CE0: IC2.24 (CE0)
CH1: IC3.2 (A0), R29.2, R43.2
CH2: IC3.5 (A1), R25.2, R44.2
CH3: R32.2, R45.2
D3: JETSON1.ANODE
D4: JETSON.ANODE
EN: R36.1, R52.2, U3.3 (EMI)
GND: C2.1, C14.1, C15.1, C16.1, C18.1, I2C.GND, IC2.9 (GND), IC2.14 (GND), IC2.20 (GND), IC2.25 (GND), IC2.30 (GND), IC2.34 (GND), IC2.39 (GND), IC4.1 (A0), IC4.2 (A1), IC4.3 (A2), IC4.4 (A3), IC4.5 (A4), IC4.14 (VSS), IC4.24 (A5), ICSP1.6, LED-SPI.GND, R1.1, R3.1, R5.1, R10.1, R13.2, R46.1, R47.2, R48.2, R59.2, T1.2 (E), T2.2 (E), U$5.2 (2:CA1), U$5.3 (3:CA2), U$8.5 (5:GND)
GPIO4: IC2.7 (GPIO4)
GPIO5: IC2.29 (GPIO5)
GPIO6: IC2.31 (GPIO6)
GPIO12: IC2.32 (GPIO12)
GPIO13: IC2.33 (GPIO13)
GPIO16: IC2.36 (GPIO16)
GPIO17: IC2.11 (GPIO17)
GPIO18: IC2.12 (GPIO18)
GPIO19: IC2.35 (GPIO19)
GPIO20: IC2.38 (GPIO20)
GPIO21: IC2.40 (GPIO21)
GPIO22: IC2.15 (GPIO22)
GPIO23: IC2.16 (GPIO23)
GPIO24: IC2.18 (GPIO24)
GPIO25: IC2.22 (GPIO25)
GPIO26: IC2.37 (GPIO26)
GPIO27: IC2.13 (GPIO27)
JETSON_RX: IC1.31 (PD1(TXD)), IC2.10 (RX), R62.2
JETSON_TX: IC1.30 (PD0(RXD)), IC2.8 (TX), R41.2
J_CH1: IC3.3 (B0), U$5.7 (7:OUT1)
J_CH2: IC3.6 (B1), U$5.6 (6:OUT2)
LED_MOSI: LED-SPI.DI
LED_SCK: LED-SPI.CI
MISO: IC2.21 (MISO)
MLITI_SEL: R57.1
MOSI: IC2.19 (MOSI)
unnamed: R28.2, R38.2, U$9.2 (2:GATE1)
unnamed: R14.1, R20.2, U$27.3 (3:DRAIN)
unnamed: IC1.8 (PB7(XTAL2/TOSC2)), X2.3
unnamed: C13.2, IC1.20 (AREF)
unnamed: C13.1, X2.2
unnamed: IC4.25 (EXTCLK), R1.2
unnamed: R11.1, U$27.1 (1:GATE)
unnamed: R17.1, ST.I/O
unnamed: R30.2, R40.2, U$11.2 (2:GATE1)
unnamed: D3.A (ANODE), R6.1, R54.2, U$9.3 (3:DRAIN2)
unnamed: 2.I/O, R30.1
unnamed: R20.1, TH.I/O
unnamed: R41.1, TP1.1
unnamed: R18.1, U$28.1 (1:GATE)
unnamed: R15.1, U$11.5 (5:GATE2), U$11.6 (6:DRAIN1)
unnamed: JETSON1.CATHODE, R5.2
unnamed: JETSON.CATHODE, R10.2
unnamed: D6.A (ANODE), R21.1, R55.2, U$11.3 (3:DRAIN2)
unnamed: D6.K (CATHODE), R24.2, U$20.2 (A)
unnamed: R25.1, U$20.4 (Y)
unnamed: 3.I/O, R37.1
unnamed: R53.1, U$21.5 (5:GATE2), U$21.6 (6:DRAIN1)
unnamed: D3.K (CATHODE), R27.2, U$14.2 (A)
unnamed: R29.1, U$14.4 (Y)
unnamed: D2.A (ANODE), R26.1, R56.2, U$21.3 (3:DRAIN2)
unnamed: D2.K (CATHODE), R31.2, U$23.2 (A)
unnamed: R32.1, U$23.4 (Y)
unnamed: R17.2, R19.1, U$28.3 (3:DRAIN)
unnamed: R62.1, TP2.1
unnamed: JP2.2, R14.2, R19.2
unnamed: IC4.6 (LED0), R33.2
unnamed: IC4.7 (LED1), R34.2
unnamed: 1.I/O, R28.1
unnamed: IC3.15 (EN), R51.2, R52.1
unnamed: R37.2, R39.2, U$21.2 (2:GATE1)
unnamed: C23.2, IC5.4 (BYPASS)
unnamed: C10.2, D5.1 (C), IC5.1 (VIN), IC5.3 (ON/OFF)
unnamed: R42.2, RC_PWR.CATHODE
unnamed: R33.1, R47.1, U$5.1 (1:AN1)
unnamed: R34.1, R48.1, U$5.4 (4:AN2)
unnamed: IC1.32 (PD2(INT0)), U$8.7 (7:OUT1)
unnamed: IC1.1 (PD3(INT1)), U$8.6 (6:OUT2)
unnamed: R43.1, R49.2, U$8.1 (1:AN1)
unnamed: R44.1, R50.2, U$8.4 (4:AN2)
unnamed: R45.1, U7.1 (A)
unnamed: R46.2, U7.3 (EMI)
unnamed: R4.1, U$9.5 (5:GATE2), U$9.6 (6:DRAIN1)
unnamed: T2.3 (C), U3.2 (C)
unnamed: R12.2, U3.1 (A)
unnamed: R2.2, R13.1, T2.1 (B)
unnamed: T1.3 (C), U4.2 (C)
unnamed: R58.2, U4.1 (A)
unnamed: R57.2, R59.1, T1.1 (B)
unnamed: IC1.7 (PB6(XTAL1/TOSC1)), X2.1
NC0: IC2.4 (5V)
NC1: IC2.6 (GND)
OE_PIN: IC4.23 (OE), R3.2
PICO_5V: R12.1, R58.1
RCH1: IC3.4 (Y0), U$28.2 (2:SOURCE)
RCH2: IC3.7 (Y1), U$27.2 (2:SOURCE)
RC_+B_3V3: C1.2, C3.2, C12.2, C17.2, C22.2, IC3.16 (VCC), IC5.5 (VOUT), JP2.1, R11.2, R18.2, RC_3V3.TP, U3.4 (COL), U4.4 (COL), U$5.8 (8:VDD_), U$14.5 (VCC), U$20.5 (VCC), U$23.5 (VCC)
RC_GND: 1.GND, 2.GND, 3.GND, C1.1, C3.1, C10.1, C12.1, C17.1, C22.1, C23.1, IC3.8 (GND), IC5.2 (GND), R16.1, R24.1, R27.1, R31.1, R36.2, R38.1, R39.1, R40.1, R42.1, R49.1, R50.1, R51.1, R54.1, R55.1, R56.1, R60.2, ST.GND, TH.GND, U7.2 (C), U$5.5 (5:GND), U$8.2 (2:CA1), U$8.3 (3:CA2), U$9.1 (1:SOURCE1), U$9.4 (4:SOURCE2), U$11.1 (1:SOURCE1), U$11.4 (4:SOURCE2), U$14.3 (GND), U$20.3 (GND), U$21.1 (1:SOURCE1), U$21.4 (4:SOURCE2), U$23.3 (GND)
SCL: I2C.SCL, IC1.28 (PC5(ADC5/SCL)), IC2.5 (SCL), IC4.26 (SCL)
SCLK: IC2.23 (SCLK)
SDA: I2C.SDA, IC1.27 (PC4(ADC4/SDA)), IC2.3 (SDA), IC4.27 (SDA)
SEL: IC3.1 (SEL), R16.2, R60.1, U4.3 (EMI)
VCC_RC: 1.VCC, 2.VCC, 3.VCC, D5.2 (A), JP2.3, R4.2, R6.2, R15.2, R21.2, R26.2, R53.2, RC_PWR.ANODE, ST.VCC, TH.VCC

Notes on the sheet:
2.0.19
Jetson Nano
PWM Controller
Address 0x40
MULTIPLEXERS
Serial
*Signal to the car body
steering
throttle
OUT(TO SERVO,ESC)
SPI_LED
MC74HC157A
SN74LVC1G17
INPUT 1
INPUT 2
INPUT 3
OUTPUT 1,2
PWM OUTPUT
REVISION
SELECTOR CONTROL
2021/10/28 Rev 2.0.14 ボディ装着のため、基板レイアウト変更,RC電源のみで走行可能、プロポマルチ対応,RC GND共通化
LDO 3V3
受信機から入力
ESC
サーボ
RC +B
2021/10/29 Rev 2.0.15 絶縁化
RC_AREA
Jetson AREA
I2C
2021/11/11 Rev 3.0.0 328PからPICOへ変更,MOS-FETを変更,EN追加、SEL絶縁修正
T2N7002AK
ＡＴＭＥＧＡ３２８Ｐ－ＡＵ
ICSP

Board: 2 copper layers, 75.5 x 50.0 mm, 115 parts (54 on the bottom side), 76 nets.

Other parts of the board:
U$1, U$2, U$3, U$29: MARK_POINT_3MM
U$4: LOGO_FABO_L_BOTTOM
U$30: LOGO_FABO_L

## EAGLE design 0612_jetracer/PCB/612_jetracer_328_020020.brd

Schematic: 612_jetracer_328_020020.sch

Parts:
C1, C2, C9: 0.1uF; 0603
C3: 0.1uF; 0402
C4, C5, C10, C17, C19: 0.1uF/0402; 0402
C6: 10uF; 0603
C7: 10uF/0402; 0402
C8: 20pF/0402; 0402
C11, C15: 4.7uF; 0603
C12: 10uF; 0402
C13, C14: 0.01uF; 0603
C16, C21: 1uF; 0603
D1: 1N4148W; SOD3715X135
D2: CUS05F40
D4, D6, D7: DIODE-SOD-323; SOD-323
FRONT_LED: RC_LIGHT; PNHEADER_2.54_SMT_LEDLIGHT
I2C: FABO-I2C_BM04B; I2C-BM04B-PASS-1
IC1: ATMEGA328P-AU; TQFP-32
IC2: JETSON_NANO_NOBORDER; JETSON_NANO_NOBOARDER
IC3: MULTIPLEXERSMC74HC157A; TSSOP-16
IC4: PCA9685_BOTTOM
IC5, IC7: LP2985-33DBV; SOT-23-5
ICSP1: ICSP_AVR-TC_NOHOLE; TC2030
JETSON: GREEN; 0603
LED-SPI: FABO-SPI-LED-BM04B; SPI-BM04B-PASS-1
M1, M4: MOSFET-N_FDV301N; SOT-23
Q1, Q2: MOSFET-N_FDN335N; SUPERSOT-3
R1, R3, R14, R19, R28, R29, R32, R36: 10K/0402; 0402
R2, R22, R23, R38: 10K; 0603
R4, R6, R15, R16: 330/0402; 0402
R5, R12, R13, R33: 470; 0603
R7, R8, R9, R43: 0/0402; 0402
R10, R37: 1K; 0603
R11, R18: 5.1K/0402; 0402
R17, R26, R27, R34, R44, R45, R46: DNP/0402; 0402
R20, R21, R31: 0; 0603
R24, R64, R65, R66, R70, R71, R72: 4.7K/0402; 0402
R25, R30: 220/0402; 0402
R35, R55, R56, R57, R58, R59, R60: 1K/0402; 0402
R39, R40: 75; 0603
R41, R42: DNF; 0603
R61, R62, R63: 100/0402; 0402
R67, R68, R69: 100K/0402; 0402
RC: RED; 0603
RC_POWER: ORANGE; 0603
REAR_LED: RC_LIGHT; PNHEADER_2.54_SMT_LEDLIGHT
S1: SLIDE-SSSS810701; SSSS810701
T1, T2: TRANSISTOR-NPN; SOT-23
TP1, TP2, TP3, TP4, TP5, TP6: TP-15
U3, U7: TLP291A; 11-3C1
U5: TLP2270
U12, U21: SSM6N7002KFU; US6
U20, U23: SN74LVC1G17; SOT-23
U$1: RC_17PIN_OUTIN; PNHEADER_2.54_SMT_17PIN_RC_TT01_02
U$6, U$10: SSM6N7002KFU; US6
U$7: SN74LVC1G17; SOT-23
U$8: TLP2270
U$11: KC2016Z
X2: 16MHz; CSTNE_V_C

Connections:
0: C9.1, C10.1, C14.1, C15.1, C17.1, C19.1, C21.1, IC3.8 (GND), IC3.15 (EN), IC5.2 (GND), R29.1, R32.2, R33.2, T1.2 (E), U5.2 (2:CA1), U5.3 (3:CA2), U$1.3:GND3 (3:GND), U$1.6:GND2 (6:GND), U$1.9:GND1 (9:GND), U$1.13:ST_GND (13:GND), U$1.17:TH_GND (17:GND), U$8.5 (5:GND)
3V3: C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C12.2, IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), IC2.1 (3V3), IC2.17 (3V3), IC4.28 (VDD), ICSP1.2, R2.2, R22.2, R23.2, R43.2, U3.4 (COL), U5.8 (8:VDD_), U$11.#4 (4:VCC)
5V: FRONT_LED.2:POWER, I2C.5V (VCC), IC2.2 (5V), LED-SPI.5V (VCC), R30.2, REAR_LED.2:POWER, U$8.1 (1:AN1), U$8.4 (4:AN2)
AVR_MISO: IC1.16 (PB4(MISO)), ICSP1.1
AVR_MOSI: IC1.15 (PB3(MOSI/OC2)), ICSP1.4, LED-SPI.DI
AVR_RESET: IC1.29 (PC6(/RESET)), ICSP1.5, R2.1
AVR_RX: IC1.30 (PD0(RXD)), R12.2, R45.1
AVR_SCK: IC1.17 (PB5(SCK)), ICSP1.3, LED-SPI.CI
AVR_TX: IC1.31 (PD1(TXD)), R13.2, R46.1
CE0: IC2.24 (CE0)
D3: IC1.14 (PB2(SS/OC1B)), RC.ANODE
D4: IC1.2 (PD4(XCK/T0)), JETSON.ANODE
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.2, C8.2, C12.1, I2C.GND, IC1.3 (GND), IC1.5 (AGND), IC1.21 (GND), IC2.9 (GND), IC2.14 (GND), IC2.20 (GND), IC2.25 (GND), IC2.30 (GND), IC2.34 (GND), IC2.39 (GND), IC4.1 (A0), IC4.2 (A1), IC4.3 (A2), IC4.4 (A3), IC4.5 (A4), IC4.14 (VSS), IC4.24 (A5), ICSP1.6, LED-SPI.GND, M1.2 (S), M4.2 (S), R1.1, R3.1, R5.1, R10.1, R17.1, R24.2, R26.1, R36.1, R41.1, R42.1, R44.1, S1.3, T2.2 (E), TP3.1, U5.5 (5:GND), U$6.1 (1:SOURCE1), U$6.4 (4:SOURCE2), U$11.#2 (2:CASE_GND), X2.2
GPIO4: IC2.7 (GPIO4)
GPIO5: IC2.29 (GPIO5)
GPIO6: IC2.31 (GPIO6)
GPIO12: IC2.32 (GPIO12)
GPIO13: IC2.33 (GPIO13)
GPIO16: IC2.36 (GPIO16)
GPIO17: IC2.11 (GPIO17)
GPIO18: IC2.12 (GPIO18)
GPIO19: IC2.35 (GPIO19)
GPIO20: IC2.38 (GPIO20)
GPIO21: IC2.40 (GPIO21)
GPIO22: IC2.15 (GPIO22)
GPIO23: IC2.16 (GPIO23)
GPIO24: IC2.18 (GPIO24)
GPIO25: IC2.22 (GPIO25)
GPIO26: IC2.37 (GPIO26)
GPIO27: IC2.13 (GPIO27)
MISO: IC2.21 (MISO)
MOSI: IC2.19 (MOSI)
unnamed: IC4.7 (LED1), R17.2, U$6.2 (2:GATE1)
unnamed: IC3.3 (B0), Q1.D, R14.1
unnamed: C1.2, IC1.20 (AREF)
unnamed: IC1.8 (PB7(XTAL2/TOSC2)), X2.3
unnamed: R12.1, TP1.1
unnamed: IC4.23 (OE), R3.2
unnamed: C8.1, IC4.25 (EXTCLK), R1.2, U$11.#3 (3:OUTPUT)
unnamed: R16.2, U5.4 (4:AN2)
unnamed: R15.2, U5.1 (1:AN1)
unnamed: R9.1, R28.2
unnamed: R7.2, U$7.4 (Y)
unnamed: IC4.6 (LED0), R26.2, U$6.5 (5:GATE2)
unnamed: Q2.S, U$8.6 (6:OUT2)
unnamed: IC1.7 (PB6(XTAL1/TOSC1)), X2.1
unnamed: IC1.9 (PD5(T1)), S1.2
unnamed: R13.1, TP2.1
unnamed: R5.2, RC.CATHODE
unnamed: JETSON.CATHODE, R10.2
unnamed: R4.2, U$6.6 (6:DRAIN1)
unnamed: R6.2, U$6.3 (3:DRAIN2)
unnamed: R6.1, U$8.2 (2:CA1)
unnamed: R4.1, U$8.3 (3:CA2)
unnamed: R25.2, R27.1, U3.1 (A)
unnamed: R27.2, T1.3 (C), U3.2 (C)
unnamed: R28.1, R32.1, T1.1 (B)
unnamed: R33.1, RC_POWER.CATHODE
unnamed: R35.1, R36.2, T2.1 (B)
unnamed: R34.1, T2.3 (C), U7.2 (C)
unnamed: C14.2, IC5.4 (BYPASS)
unnamed: IC5.3 (ON/OFF), R31.2
unnamed: R30.1, R34.2, U7.1 (A)
unnamed: R21.2, U$1.15:TH_SINGNAL (15:SIGNAL_TH)
unnamed: R20.2, U$1.11:ST_SIGNAL (11:SIGNAL_ST)
unnamed: Q1.S, U$8.7 (7:OUT1)
unnamed: IC4.19 (LED12), R37.2
unnamed: Q2.G, R18.1
unnamed: Q1.G, R11.1
unnamed: IC4.18 (LED11), R38.2
unnamed: IC3.6 (B1), Q2.D, R19.1
unnamed: M1.1 (G), R37.1, R41.2
unnamed: M4.1 (G), R38.1, R42.2
unnamed: FRONT_LED.1:GND, R39.2
unnamed: M1.3 (D), R39.1
unnamed: M4.3 (D), R40.1
unnamed: R40.2, REAR_LED.1:GND
unnamed: R43.1, R44.2, U$11.#1 (1:INH)
unnamed: D4.A (ANODE), R56.1, R70.2, U$10.3 (3:DRAIN2)
unnamed: D4.K (CATHODE), R64.2, U$7.2 (A)
unnamed: D6.A (ANODE), R58.1, R71.2, U12.3 (3:DRAIN2)
unnamed: D6.K (CATHODE), R65.2, U20.2 (A)
unnamed: R8.2, U20.4 (Y)
unnamed: D7.A (ANODE), R60.1, R72.2, U21.3 (3:DRAIN2)
unnamed: D7.K (CATHODE), R66.2, U23.2 (A)
unnamed: R9.2, U23.4 (Y)
unnamed: R61.2, R69.2, U$10.2 (2:GATE1)
unnamed: R63.2, R67.2, U21.2 (2:GATE1)
unnamed: C13.2, IC7.4 (BYPASS)
unnamed: C16.2, D1.1 (C), IC7.1 (VIN), IC7.3 (ON/OFF)
unnamed: R55.1, U$10.5 (5:GATE2), U$10.6 (6:DRAIN1)
unnamed: R62.2, R68.2, U12.2 (2:GATE1)
unnamed: R57.1, U12.5 (5:GATE2), U12.6 (6:DRAIN1)
unnamed: R59.1, U21.5 (5:GATE2), U21.6 (6:DRAIN1)
NC0: IC2.4 (5V)
NC1: IC2.6 (GND)
NC3: U$1.10:NC1 (10:NC)
NC4: U$1.14:NC2 (14:NC)
PCH1: IC3.2 (A0), R7.1, R15.1, R61.1, TP5.1, U$1.7:SIGNAL1 (7:SIGNAL_CH1)
PCH2: IC3.5 (A1), R8.1, R16.1, R62.1, TP6.1, U$1.4:SIGNAL2 (4:SINGNAL_CH2)
PCH3: IC1.26 (PC3(ADC3)), R24.1, U3.3 (EMI)
PCH6: IC3.1 (SEL), R29.2, U7.3 (EMI)
PCH_1: IC1.13 (PB1(OC1A)), R35.2
PCH_3: R63.1, U$1.1:SIGNAL3 (1:SIGNAL_CH3)
PH1-328: IC1.32 (PD2(INT0)), U5.7 (7:OUT1)
PH2_328: IC1.1 (PD3(INT1)), U5.6 (6:OUT2)
RCH1: IC3.4 (Y0), R20.1
RCH2: IC3.7 (Y1), R21.1
RC_+B_3V3: C11.2, IC7.5 (VOUT), TP4.1, U20.5 (VCC), U23.5 (VCC), U$7.5 (VCC)
RC_GND: C11.1, C13.1, C16.1, IC7.2 (GND), R64.1, R65.1, R66.1, R67.1, R68.1, R69.1, R70.1, R71.1, R72.1, U12.1 (1:SOURCE1), U12.4 (4:SOURCE2), U20.3 (GND), U21.1 (1:SOURCE1), U21.4 (4:SOURCE2), U23.3 (GND), U$7.3 (GND), U$10.1 (1:SOURCE1), U$10.4 (4:SOURCE2)
RX: IC2.10 (RX), R46.2
SCL: I2C.SCL, IC1.28 (PC5(ADC5/SCL)), IC2.5 (SCL), IC4.26 (SCL), R22.1
SCLK: IC2.23 (SCLK)
SDA: I2C.SDA, IC1.27 (PC4(ADC4/SDA)), IC2.3 (SDA), IC4.27 (SDA), R23.1
TX: IC2.8 (TX), R45.2
VCC_R: C17.2, C19.2, C21.2, D2.C (CATHODE), IC3.16 (VCC), IC5.1 (VIN), R14.2, R19.2, R31.1, U7.4 (COL)
VCC_RC: D1.2 (A), D2.A (ANODE), R55.2, R56.2, R57.2, R58.2, R59.2, R60.2, RC_POWER.ANODE, U$1.2:VCC3 (2:VCC), U$1.5:VCC2 (5:VCC), U$1.8:VCC1 (8:VCC), U$1.12:ST_VCC (12:VCC_ST), U$1.16:TH_VCC (16:VCC_TH)
VCC_RC1_5V: C9.2, C10.2, C15.2, IC5.5 (VOUT), R11.2, R18.2, R25.1, U$8.8 (8:VDD_)

Notes on the sheet:
2.0.20
Jetson Nano
PWM Controller
Address 0x40
MULTIPLEXERS
D11
D12
D13
Arduino
Serial
ICSP
*Signal from radio control receiver
*Signal to the car body
steering
throttle
Expansion channel
OUT
SPI_LED
MC74HC157A
RC CONTROL AREA
LP2985-5
ATTENTION. ※ TT-01 or TT-02 USE ONLY
ＡＴＭＥＧＡ３２８Ｐ－ＡＵ
RC_Car Connect
option
I2C(OLED)
SN74LVC1G17
INPUT 1
INPUT 2
INPUT 3
LDO 3V3
RC_AREA
Jetson Serial

Board: 2 copper layers, 84.4 x 80.0 mm, 131 parts (46 on the bottom side), 93 nets.

Other parts of the board:
U$2, U$3: LOGO_FABO_L

Notices in the files:
parts and their libraries:
FaBo-etc: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
SparkFun-Jumpers: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
FaBo-etc: Released under the Creative Commons
