# Repository FaBoPlatform/FaBo

## EAGLE design 0612_jetracer/PCB/612_jetracer_328_020027.brd

Parts:
ANA2: AD2; TP-15
ANA6: TP-15
BEC1, BEC50, BEC62TP, BEC62TP1: TP-15
C1, C2, C17, C18, C20, C23, C24: 0.1uF; 0603
C3, C4, C5, C7, C22: 0.1uF; 0402
C6: 10uF; 0603
C8: 10uF/0402; 0402
C9: 20pF/0402; 0402
C14: 0.01uF; 0603
C15: 2.2uF; 0603
C21: 1uF; 0603
D2: CUS05F40
DONKEY: YELLOW; 0603
I2C: FABO-I2C; I2C-SM04B-PASS-1-FL
IC1: ATMEGA328P-AU; TQFP-32
IC2: JETSON_NANO_NOBORDER; JETSON_NANO_NOBOARDER
IC3: MULTIPLEXERSMC74HC157A; TSSOP-16
IC4: PCA9685_BOTTOM
IC5: LP2985-33DBV; SOT-23-5
ICSP1: ICSP_AVR-TC_NOHOLE; TC2030
JETSON: GREEN; 0603
JP1, JP2: FABO-SMD-JUMPER-SELECT-NARROW; SMD-JUMPER_SELECT_NARROW
LED0TP, LED1TP: TP-15
Q1, Q2, Q3, Q4, Q5: MOSFET-N_FDN335N; SUPERSOT-3
R1, R3: 0; 0603
R2, R14, R19, R22, R23, R44, R45: 10K; 0603
R4, R17, R41, R42: 330/0402; 0402
R5, R12, R13: 470; 0603
R6, R15, R16, R26, R27, R29: 330; 0603
R7, R43: DNP/0402; 0402
R8, R34, R35: 10; 0603
R9, R25: 1K/0402; 0402
R10, R40: 1K; 0603
R11, R18: 5.1K; 0603
R20, R21: 27; 0603
R24, R32, R33: 100K; 0603
R28: 4.7K/0402; 0402
R30: 180; 0603
R31: DNP; 0402
R36, R37, R38, R39: DNP; 0603
RC: RED; 0603
RCPWR: ORANGE; 0603
SPI-LED: FABO-SPI-LED; SPI-SM04B-PASS-1-FL
SW1: IS-2245S-G
T5, T6: SN74LVC2G04; SOT-23-6
TP1, TP2, TP3: TP-15
U1, U8, U9, U10, U11: TLP2361
U7: TLP291A; 11-3C1
U$1: RC_17PIN_OUTIN; PNHEADER_2.54_SMT_17PIN_RC_TT01_02
U$3: RC_3PIN_POWEROUT; PNHEADER_2.54_SMT_3PIN_RC_TT01_02
U$9: RN1401; SC-59
U$10: SSM6N7002KFU; US6
U$11: KC2016Z
X2: 16MHz; CSTNE_V_C

Connections:
0: BEC62TP1.1, C7.1, C14.1, C15.1, C18.1, C20.1, C21.1, C23.1, C24.1, IC3.8 (GND), IC3.15 (EN), IC5.2 (GND), Q3.S, Q4.S, Q5.S, R9.2, R24.2, R28.2, R32.2, R33.2, T6.2 (GND), U10.4 (GND), U11.4 (GND), U$1.3:GND3 (3:GND), U$1.6:GND2 (6:GND), U$1.9:GND1 (9:GND), U$1.13:ST_GND (13:GND), U$1.17:TH_GND (17:GND), U$3.3:GND3 (3:GND)
3V3: C2.2, C3.2, C4.2, C5.2, C6.1, C8.1, C17.2, C22.2, IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), IC2.1 (3V3), IC2.17 (3V3), IC4.28 (VDD), ICSP1.2, R2.2, R22.2, R23.2, R25.1, R44.2, R45.2, T5.5 (VCC), U1.6 (VCC), U8.6 (VCC), U9.6 (VCC), U$11.#1 (1:INH), U$11.#4 (4:VCC)
5V: I2C.5V (VCC), IC2.2 (5V), R4.1, R17.1, SPI-LED.5V (VCC)
AD2: ANA2.1, IC1.25 (PC2(ADC2))
AD6: ANA6.1, IC1.19 (ADC6)
AVR_MISO: IC1.16 (PB4(MISO)), ICSP1.1, R38.2
AVR_MOSI: IC1.15 (PB3(MOSI/OC2)), ICSP1.4, R37.2, SPI-LED.DI
AVR_RESET: IC1.29 (PC6(/RESET)), ICSP1.5, R2.1, R36.2
AVR_RX: IC1.30 (PD0(RXD)), R12.2
AVR_SCK: IC1.17 (PB5(SCK)), ICSP1.3, R39.2, SPI-LED.CI
AVR_TX: IC1.31 (PD1(TXD)), R13.2
B0_BEC: IC3.3 (B0), Q1.D, R19.1
B0_INPUT: Q1.S, T6.6 (1Y)
B0_NOT: T6.1 (1A), U10.5 (VO)
B1_BEC: IC3.6 (B1), Q2.D, R14.1
B1_INPUT: Q2.S, T6.4 (2Y)
B1_NOT: T6.3 (2A), U11.5 (VO)
BEC_50: BEC50.1, C15.2, C18.2, C23.2, C24.2, IC5.5 (VOUT), R11.2, R18.2, T6.5 (VCC), U10.6 (VCC), U11.6 (VCC)
BEC_60: C7.2, C20.2, C21.2, D2.C (CATHODE), IC3.16 (VCC), IC5.1 (VIN), IC5.3 (ON/OFF), R14.2, R19.2, U7.4 (COL)
BEC_62: BEC62TP.1, D2.A (ANODE), R6.2, R15.2, R16.2, RCPWR.ANODE, U$1.2:VCC3 (2:VCC), U$1.5:VCC2 (5:VCC), U$1.8:VCC1 (8:VCC), U$1.12:ST_VCC (12:VCC_ST), U$1.16:TH_VCC (16:VCC_TH), U$3.2:VCC3 (2:VCC)
CE0: IC2.24 (CE0)
D3: IC1.1 (PD3(INT1)), RC.ANODE
D4: IC1.2 (PD4(XCK/T0)), JETSON.ANODE
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.2, C8.2, C9.2, C17.1, C22.1, I2C.GND, IC1.3 (GND), IC1.5 (AGND), IC1.21 (GND), IC2.9 (GND), IC2.14 (GND), IC2.20 (GND), IC2.25 (GND), IC2.30 (GND), IC2.34 (GND), IC2.39 (GND), IC4.1 (A0), IC4.2 (A1), IC4.3 (A2), IC4.4 (A3), IC4.5 (A4), IC4.14 (VSS), IC4.24 (A5), ICSP1.6, R1.1, R3.1, R5.1, R10.1, R40.1, SPI-LED.GND, SW1.3, SW1.6, T5.2 (GND), TP3.1, U1.4 (GND), U7.2 (C), U8.4 (GND), U9.4 (GND), U$9.E, U$10.1 (1:SOURCE1), U$10.4 (4:SOURCE2), U$11.#2 (2:CASE_GND), X2.2
GPIO4: IC2.7 (GPIO4), R36.1
GPIO5: IC2.29 (GPIO5)
GPIO6: IC2.31 (GPIO6)
GPIO12: IC2.32 (GPIO12)
GPIO13: IC2.33 (GPIO13)
GPIO16: IC2.36 (GPIO16)
GPIO17: IC2.11 (GPIO17)
GPIO18: IC2.12 (GPIO18)
GPIO19: IC2.35 (GPIO19)
GPIO20: IC2.38 (GPIO20)
GPIO21: IC2.40 (GPIO21)
GPIO22: IC2.15 (GPIO22)
GPIO23: IC2.16 (GPIO23)
GPIO24: IC2.18 (GPIO24)
GPIO25: IC2.22 (GPIO25)
GPIO26: IC2.37 (GPIO26)
GPIO27: IC2.13 (GPIO27)
LED0: IC4.6 (LED0), LED0TP.1, U$10.5 (5:GATE2)
LED0_5: R7.2, R41.1, U10.3 (CATHODE)
LED0_5V: R41.2, U$10.3 (3:DRAIN2)
LED1: IC4.7 (LED1), U$10.2 (2:GATE1)
LED1_5: R42.1, R43.2, U11.3 (CATHODE)
LED1_5V: LED1TP.1, R42.2, U$10.6 (6:DRAIN1)
MISO: IC2.21 (MISO), R38.1
MODESWITCH: IC1.9 (PD5(T1)), SW1.2, SW1.5
MOSI: IC2.19 (MOSI), R37.1
unnamed: R4.2, R7.1, U10.1 (ANODE)
unnamed: JP1.1, R44.1
unnamed: C1.2, IC1.20 (AREF)
unnamed: IC1.8 (PB7(XTAL2/TOSC2)), X2.3
unnamed: R12.1, TP1.1
unnamed: IC4.23 (OE), R3.2
unnamed: DONKEY.ANODE, IC1.13 (PB1(OC1A))
unnamed: R15.1, U9.1 (ANODE)
unnamed: T5.1 (1A), U9.5 (VO)
unnamed: T5.3 (2A), U8.5 (VO)
unnamed: R16.1, U8.1 (ANODE)
unnamed: R17.2, R43.1, U11.1 (ANODE)
unnamed: JP2.1, R45.1
unnamed: IC1.7 (PB6(XTAL1/TOSC1)), X2.1
unnamed: R13.1, TP2.1
unnamed: R5.2, RC.CATHODE
unnamed: JETSON.CATHODE, R10.2
unnamed: R26.1, U1.3 (CATHODE)
unnamed: R6.1, U1.1 (ANODE)
unnamed: Q3.G, R8.1, R24.1
unnamed: R9.1, RCPWR.CATHODE
unnamed: BEC1.1, R31.1, U1.5 (VO), U$9.B
unnamed: Q3.D, R26.2
unnamed: Q4.D, R27.2
unnamed: R27.1, U9.3 (CATHODE)
unnamed: Q5.D, R29.2
unnamed: R29.1, U8.3 (CATHODE)
unnamed: C14.2, IC5.4 (BYPASS)
unnamed: Q5.G, R32.1, R34.2
unnamed: R21.2, U$1.15:TH_SINGNAL (15:SIGNAL_TH)
unnamed: R20.2, U$1.11:ST_SIGNAL (11:SIGNAL_ST)
unnamed: Q4.G, R33.1, R35.2
unnamed: Q2.G, R11.1
unnamed: Q1.G, R18.1
unnamed: C9.1, IC4.25 (EXTCLK), R1.2, U$11.#3 (3:OUTPUT)
unnamed: R30.1, U7.1 (A)
unnamed: DONKEY.CATHODE, R40.2
NC0: IC2.4 (5V)
NC1: IC2.6 (GND)
NC3: U$1.10:NC1 (10:NC)
NC4: U$1.14:NC2 (14:NC)
PCH1: IC3.2 (A0), R34.1, U$1.7:SIGNAL1 (7:SIGNAL_CH1)
PCH2: IC3.5 (A1), R35.1, U$1.4:SIGNAL2 (4:SINGNAL_CH2)
PCH3_328: IC1.26 (PC3(ADC3)), R25.2, R31.2, U$9.C
PCH6: IC3.1 (SEL), R28.1, U7.3 (EMI)
PCH_1: IC1.32 (PD2(INT0)), R30.2
PCH_3: R8.2, U$1.1:SIGNAL3 (1:SIGNAL_CH3)
PH1-328: IC1.23 (PC0(ADC0)), T5.4 (2Y)
PH2_328: IC1.24 (PC1(ADC1)), T5.6 (1Y)
RCH1: IC3.4 (Y0), R20.1
RCH2: IC3.7 (Y1), R21.1
RX: IC2.10 (RX)
SCL: I2C.SCL, IC1.28 (PC5(ADC5/SCL)), IC2.5 (SCL), IC4.26 (SCL), JP1.2, R22.1
SCLK: IC2.23 (SCLK), R39.1
SDA: I2C.SDA, IC1.27 (PC4(ADC4/SDA)), IC2.3 (SDA), IC4.27 (SDA), JP2.2, R23.1
TX: IC2.8 (TX)

Notes on the sheet:
2.0.27
Jetson Nano
PWM Controller
Address 0x40
MULTIPLEXERS
D11
D12
D13
Arduino
Serial
ICSP
*Signal from radio control receiver
*Signal to the car body
steering
throttle
Expansion channel
OUT
SPI_LED
MC74HC157A
RC CONTROL AREA
LP2985-5
ATTENTION. ※ TT-02 USE ONLY
ＡＴＭＥＧＡ３２８Ｐ－ＡＵ
RC_Car Connect
option
CRISTAL OSCILLATOR(OPTION)
I2C
OUTLET
水晶発振を取り付けた場合は、取り付けなし

Board: 2 copper layers, 84.4 x 81.0 mm, 115 parts (48 on the bottom side), 83 nets.

Other parts of the board:
U$2: LOGO_FABO_L
U$5, U$6, U$7, U$8, U$12: LOGO_SILK_GND

Notices in the files:
parts and their libraries:
FaBo-etc: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
