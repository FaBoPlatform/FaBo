# Repository FaBoPlatform/FaBo

## EAGLE design 0223_gas/pcb/223_gas.brd

Parts:
C1: 1uF; 0603
C2: 0.1uF; 0603
C3: AM-CSS811; AMS-CSS811
C4, C6: 4.7uF; 0603
IC2: LP2985-33DBV; SOT-23-5
IC3: PCA9306GM; XQFN8
J1: FABO_BRICK_I2C
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1, R2, R4: 4.7k; 0603
R3: 200k; 0603
R5: 10K; 0603
R6, R7: 100K; 0603
SJ1: SMD-JUMPER-2-OPEN
T1: 10K; 0603
TP1, TP2: TP-15
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
5V: IC2.1 (VIN), IC2.3 (ON/OFF), J1.VCC, R3.2
+3V3: C1.2, C3.6 (VDD), C4.2, C6.2, IC2.5 (VOUT), IC3.2 (VREF1), R1.2, R2.2, R4.2, R5.1, R6.2
AUX: C3.8 (AUX), R5.2, T1.1
GND: C1.1, C2.1, C3.EP (GND), C4.1, C6.1, IC2.2 (GND), IC3.1 (GND), J1.GND, R7.2, SJ1.1
unnamed: C2.2, IC3.7 (VREF2), IC3.8 (EN), R3.1
unnamed: C3.4 (PWM), C3.5 (SENSE), T1.2
unnamed: C3.7 (WAKE), R7.1
unnamed: C3.2 (RST), R4.1
unnamed: C3.1 (ADDR), R6.1, SJ1.2
SCL: C3.10 (SCL), IC3.3 (SCL1), R1.1, TP2.1
SCL_HV: IC3.6 (SCL2), J1.SCL
SDA: C3.9 (SDA), IC3.4 (SDA1), R2.1, TP1.1
SDA_HV: IC3.5 (SDA2), J1.SDA

Notes on the sheet:
1.0.1

Board: 2 copper layers, 27.9 x 39.4 mm, 21 parts (3 on the bottom side), 13 nets.

## EAGLE design 0224_distance/pcb/224_distance.brd

Parts:
C1: 1uF; 0603
C2: 0.1uF; 0603
C3: 100nF; 0603
C4: 4.7uF; 0603
IC2: LP2985-33DBV; SOT-23-5
IC3: PCA9306GM; XQFN8
J1: FABO_BRICK_I2C
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1, R2: 4.7k; 0603
R3: 200k; 0603
R4, R5: 10k; 0603
TP1, TP2: TP-15
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
VL1: ST-VL53L0XVL53; ST-VL53L0X

Connections:
5V: IC2.1 (VIN), IC2.3 (ON/OFF), J1.VCC, R3.2
+3V3: C1.2, C3.2, C4.2, IC2.5 (VOUT), R1.2, R2.2, R4.2, R5.2, VL1.1 (AVDDVCSEL), VL1.11 (AVDD)
GND: C1.1, C2.1, C3.1, C4.1, IC2.2 (GND), IC3.1 (GND), J1.GND, VL1.2 (AVSSVCSEL), VL1.3 (GND), VL1.4 (GND), VL1.6 (GND), VL1.12 (GND)
unnamed: C2.2, IC3.7 (VREF2), IC3.8 (EN), R3.1
unnamed: R4.1, VL1.5 (XSHUT)
unnamed: R5.1, VL1.7 (GPIO1)
SCL: IC3.3 (SCL1), R1.1, TP2.1, VL1.10 (SCL)
SCL_HV: IC3.6 (SCL2), J1.SCL
SDA: IC3.4 (SDA1), R2.1, TP1.1, VL1.9 (SDA)
SDA_HV: IC3.5 (SDA2), J1.SDA

Notes on the sheet:
1.0.1

Board: 2 copper layers, 27.9 x 39.4 mm, 17 parts (2 on the bottom side), 10 nets.

## EAGLE design 0224_distance/pcb/224_distance_2m.brd

Parts:
C1: 2.2uF; 0603
C2, C3: 0.1uF; 0603
C4: 4.7uF; 0603
C5: 0.01uF; 0603
C6: 1uF; 0603
IC2: LP2985-33DBV; SOT-23-5
J1: FABO_BRICK_I2C
JP1: PINHD-1X2; 1X02
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1, R2: 4.7k; 0603
R3: 200k; 0603
R4, R5: 10k; 0603
R6: 1.8k; 0603
R7: 3.3k; 0603
SJ1: SJ2W; SJ_2
TP1, TP2, TP3, TP4: TP-15
U4: PCA9306DP1; TSSOP8
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
VL1: ST-VL53L0XVL53; ST-VL53L0X

Connections:
2.8V: C1.2, C3.2, C4.2, IC2.5 (VOUT), R1.2, R2.2, R4.2, R5.2, U4.VREF1, VL1.1 (AVDDVCSEL), VL1.11 (AVDD)
3.3V: R6.1, R7.2, SJ1.3
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, IC2.2 (GND), J1.GND, R7.1, U4.GND, VL1.2 (AVSSVCSEL), VL1.3 (GND), VL1.4 (GND), VL1.6 (GND), VL1.12 (GND)
unnamed: C2.2, R3.1, U4.EN, U4.VREF2
unnamed: R3.2, SJ1.2
unnamed: C5.2, IC2.4 (BYPASS)
unnamed: JP1.2, R4.1, VL1.5 (XSHUT)
unnamed: JP1.1, R5.1, VL1.7 (GPIO1)
SCL: R1.1, TP2.1, U4.SCL1, VL1.10 (SCL)
SCL_HV: J1.SCL, TP4.1, U4.SCL2
SDA: R2.1, TP1.1, U4.SDA1, VL1.9 (SDA)
SDA_HV: J1.SDA, TP3.1, U4.SDA2
VCC: C6.2, IC2.1 (VIN), IC2.3 (ON/OFF), J1.VCC, R6.2, SJ1.1

Notes on the sheet:
1.0.3
ST-VL53L0X
LP2985-28DBVR

Board: 2 copper layers, 27.9 x 39.4 mm, 25 parts (5 on the bottom side), 13 nets.

## EAGLE design 0225_gps/pcb/225_gps.brd

Parts:
C1: 1uF; 0603
C2: 0.1uF; 0603
IC2: LP2985-33DBV; SOT-23-5
IC3: PCA9306GM; XQFN8
J1: FABO_BRICK_I2C
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1, R2: 2.2k; 0603
R3: 200k; 0603
R4, R5: 10K; 0603
RESET: TACT-SWITCH-SMD_KMR2; KMR2
TP1, TP2, TP3, TP4: TP-15
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
U$4: ORIGINGPS_ORG1510

Connections:
1V8: C1.2, IC2.5 (VOUT), IC3.2 (VREF1), R1.2, R2.2, U$4.4 (VCC(1V8))
5V: IC2.1 (VIN), IC2.3 (ON/OFF), J1.VCC, R3.2
GND: C1.1, C2.1, IC2.2 (GND), IC3.1 (GND), J1.GND, R4.1, R5.1, U$4.5 (GND)
unnamed: C2.2, IC3.7 (VREF2), IC3.8 (EN), R3.1
unnamed: R4.2, U$4.9 (RTS)
unnamed: TP3.1, U$4.1 (FORCE_ON)
unnamed: R5.2, RESET.3, RESET.4, TP4.1
RESET: RESET.2, U$4.8 (RESET)
SCL: IC3.3 (SCL1), R1.1, TP2.1, U$4.3 (SCL)
SCL_HV: IC3.6 (SCL2), J1.SCL
SDA: IC3.4 (SDA1), R2.1, TP1.1, U$4.10 (SDA)
SDA_HV: IC3.5 (SDA2), J1.SDA

Notes on the sheet:
1.0.0.Beta2
Reset Button

Board: 2 copper layers, 27.9 x 39.4 mm, 18 parts (2 on the bottom side), 12 nets.

## EAGLE design 0226_grideye/pcb/226_grideye.brd

Parts:
C1, C4: 1uF; 0603
C2: 0.1uF; 0603
C3: 10uF; 0603
C5: 1.5uF; 0603
GRIDEYE: PN-AMG8331; PANASONIC-AMG8831
IC2: LP2985-33DBV; SOT-23-5
IC3: PCA9306GM; XQFN8
INT: INT; TP-15
J1: FABO_BRICK_I2C
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1, R2: 4.7k; 0603
R3: 200k; 0603
R4: 10k; 0603
SJ1: OPEN; SMD-JUMPER-2-OPEN
TP1, TP2: TP-15
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
5V: IC2.1 (VIN), IC2.3 (ON/OFF), J1.VCC, R3.2
+3V3: C1.2, C3.2, GRIDEYE.9 (VDD), GRIDEYE.13 (VPP), IC2.5 (VOUT), R1.2, R2.2, SJ1.1
AD_SEL: GRIDEYE.5 (AD_SEL), R4.2, SJ1.2
GND: C1.1, C2.1, C3.1, C4.1, C5.1, GRIDEYE.6 (GND), IC2.2 (GND), IC3.1 (GND), J1.GND, R4.1
unnamed: C2.2, IC3.7 (VREF2), IC3.8 (EN), R3.1
unnamed: GRIDEYE.4 (INT), INT.1
unnamed: C5.2, GRIDEYE.12 (DVDD-PC)
unnamed: C4.2, GRIDEYE.10 (AVDD-PC)
SCL: GRIDEYE.3 (SCL), IC3.3 (SCL1), R1.1, TP2.1
SCL_HV: IC3.6 (SCL2), J1.SCL
SDA: GRIDEYE.2 (SDA), IC3.4 (SDA1), R2.1, TP1.1
SDA_HV: IC3.5 (SDA2), J1.SDA

Notes on the sheet:
1.0.0.Beta

Board: 2 copper layers, 27.9 x 39.4 mm, 19 parts (2 on the bottom side), 12 nets.

Other parts of the board:
U$3: LOGO_FABO_MS

## EAGLE design 0227_arrayrelay/pcb/226_arrayrelay.brd

Parts:
C1, C3, C5: 10uF; 0603
C2, C9: 0.1uF; 0603
C4, C6, C7, C8: 33pF; 0603
IC1: NX-PCAL6408A; NXP-PCAL6408A
J1: FABO_BRICK_I2C-S04B-PASK-2_LONG; FABO_BRICK_I2C_S04B-PASK-2_LONG
JP2: JP1E; JP1
JP3: PINHD-1X2; 1X02
L1, L2, L3, L4: COIL-0402; 0402
R9, R34: 10k; 0603-NARROW
SJ1: OPEN; SMD-JUMPER-2-OPEN
U$4: LOGO_FABO-M; LOGO_FABO_MS

Connections:
+5V: JP2.2, JP3.1; also elsewhere on the board
ADDRESS: IC1.16 (ADDR), R9.2, SJ1.2
GND: C1.1, C2.1, C3.1, C4.1, C6.1, J1.GND, JP3.2, L4.P$1 (1), R9.1; also elsewhere on the board
GPIO0: IC1.2 (P0); also elsewhere on the board
GPIO1: IC1.3 (P1); also elsewhere on the board
GPIO2: IC1.4 (P2); also elsewhere on the board
GPIO3: IC1.5 (P3); also elsewhere on the board
GPIO4: IC1.7 (P4); also elsewhere on the board
GPIO5: IC1.8 (P5); also elsewhere on the board
GPIO6: IC1.9 (P6); also elsewhere on the board
GPIO7: IC1.10 (P7); also elsewhere on the board
unnamed: IC1.1 (RESET), R34.1
unnamed: C8.2, IC1.12 (SCL), L1.P$2 (2)
unnamed: C7.2, IC1.13 (SDA), L2.P$2 (2)
unnamed: C1.2, C5.2, C9.2, IC1.14 (VDD1), IC1.15 (VDD2), L3.P$2 (2), R34.2, SJ1.1
unnamed: C5.1, C7.1, C8.1, C9.1, IC1.6 (VSS), IC1.17 (VSS), L4.P$2 (2)
SCL: C6.2, J1.SCL, L1.P$1 (1)
SDA: C4.2, J1.SDA, L2.P$1 (1)
VCC: C2.2, C3.2, J1.VCC, JP2.1, L3.P$1 (1); also elsewhere on the board

Notes on the sheet:
1.1.1
※VCCが5V以外の場合はつないではいけません。
RELAY1
RELAY2
RELAY3
RELAY4
RELAY5
RELAY6
RELAY7
RELAY8
MAIN
※外部電源入力（５V専用） 逆接続注意のこと
※I2C
※GPIOエキスパンダ
BLM15HB221

Parts:
COM1: TBL004-508
D1: 1N4188; 0603
LED1: LED-0402-NO_SILK; 0402-NO_SILK
M1: MOSFET-N_FDN335N; SUPERSOT-3
NC1: TBL004-508
R1: 1.8K; 0603-NARROW
R2: 10K; 0603-NARROW
R3, R4: 1K; 0603-NARROW
RL1: G2RL-1
U4: TLP291A; 11-3C1
U$7: TBL004-508

Connections:
+5V: D1.CATHODE, RL1.1, U4.4 (COL); also elsewhere on the board
GND: M1.S, R2.1, R3.1; also elsewhere on the board
GPIO0: LED1.CATHODE; also elsewhere on the board
unnamed: D1.ANODE, M1.D, RL1.5
unnamed: R1.1, R3.2, U4.3 (EMI)
unnamed: M1.G, R1.2, R2.2
unnamed: LED1.ANODE, U4.2 (C)
unnamed: R4.2, U4.1 (A)
unnamed: NC1.P$1, NC1.P$2, RL1.2
unnamed: COM1.P$1, COM1.P$2, RL1.4
unnamed: RL1.3, U$7.P$1, U$7.P$2
VCC: R4.1; also elsewhere on the board

Notes on the sheet:
1.1.0
COM
G2RL-1
FDN335N
1N4148
GPIO0
RELAY1

Parts:
COM2: TBL004-508
D2: 1N4188; 0603
LED2: LED-0402-NO_SILK; 0402-NO_SILK
M2: MOSFET-N_FDN335N; SUPERSOT-3
NC2: TBL004-508
R5: 1.8K; 0603-NARROW
R6: 10K; 0603-NARROW
R7, R8: 1K; 0603-NARROW
RL2: G2RL-1
U1: TLP291A; 11-3C1
U$9: TBL004-508

Connections:
+5V: D2.CATHODE, RL2.1, U1.4 (COL); also elsewhere on the board
GND: M2.S, R6.1, R7.1; also elsewhere on the board
GPIO1: LED2.CATHODE; also elsewhere on the board
unnamed: D2.ANODE, M2.D, RL2.5
unnamed: R5.1, R7.2, U1.3 (EMI)
unnamed: M2.G, R5.2, R6.2
unnamed: NC2.P$1, NC2.P$2, RL2.2
unnamed: COM2.P$1, COM2.P$2, RL2.4
unnamed: RL2.3, U$9.P$1, U$9.P$2
unnamed: LED2.ANODE, U1.2 (C)
unnamed: R8.2, U1.1 (A)
VCC: R8.1; also elsewhere on the board

Notes on the sheet:
1.1.0
COM
G2RL-1
FDN335N
1N4148
GPIO1
RELAY2

Notices in the files:
parts and their libraries:
FaBo-Capacitor: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
