# Repository FaBoPlatform/FaBo (continued)

## EAGLE design 0519_outin_jetson_nano/pcb/519_jetson_nano.brd

Parts:
A0, A1, A2, A3: FABO_BRICK_3PIN-S03B-PASK-2; FABO_BRICK_3PIN_S03B-PASK-2
C1, C2, C3: 10uF; 0603-BOTTOM
C4, C5, C6, C7: 1uF; 0603-BOTTOM
C8, C9, C10, C11: 0.1uF; 0603
D1: 1N4148; 1N4148W
GPIO4, GPIO5, GPIO6, GPIO12, GPIO13, GPIO16: FABO_BRICK_3PIN-B03B-PASK-1; FABO_BRICK_3PIN_B03B-PASK-1
I2C0: FABO_BRICK_I2C-S04B-PASK-2; FABO_BRICK_I2C_S04B-PASK-2
I2C1, I2C2: FABO_BRICK_I2C-B04B-PASK-1; FABO_BRICK_I2C_B04B-PASK-1
IC1: PCA9306_SSOP; 8PIN-SSOP
IC2: TXS0108; R-PUSON-N20
IC3: MICROCHIP-MCP3008
LOGO1: LOGO_FABO-M; LOGO_FABO_M
PWM0, PWM1, PWM2, PWM3: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
R1, R2: 10k; EXBV8V
R3: 220; EXBV8V
R4, R10, R14, R15: 3.3K; 0603-BOTTOM
R5: 390K; 0603-BOTTOM
R6: 100; 0603-BOTTOM
R7: 10K; 0603-BOTTOM
R8: 10K; EXBV8V
R9: 200K; 0603
R11, R12, R17, R18: 5.1K; 0603-BOTTOM
R13: 1M; 0603-BOTTOM
R16: 20K; 0603-BOTTOM
SERIAL: FABO_BRICK_SERIAL-B04B-PASK-1; FABO_BRICK_SERIAL_B04B-PASK-1
SJ1: SJ2W; SJ_2
SJ2, SJ3, SJ4: SMD-JUMPER-3-23SHORT; SMD-JUMPER-3
U1: ER-OLED0.96-1ER-CON30HT-1; ER-CON30HT-1
U$2: JETSON_NANO_WIDE
U$7: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
U$9: PCA9685

Connections:
3V3: C6.2, C7.2, C8.2, C9.2, C10.2, D1.CATHODE, IC1.2 (VREF1), IC2.2 (VCCA), IC3.15 (VREF), IC3.16 (VDD), R7.2, R8.5 (2), R8.6 (2), R16.2, SJ1.3, SJ2.2, SJ2.3, SJ3.1, SJ4.2, SJ4.3, U1.22 (VDD), U1.25 (VBAT), U$2.1 (3V3), U$9.24 (A5), U$9.28 (VDD)
5V: A0.VCC, A1.VCC, A2.VCC, A3.VCC, C11.2, GPIO4.VCC, GPIO5.VCC, GPIO6.VCC, GPIO12.VCC, GPIO13.VCC, GPIO16.VCC, I2C0.VCC, I2C1.VCC, I2C2.VCC, IC2.19 (VCCB), PWM0.VCC, PWM1.VCC, PWM2.VCC, PWM3.VCC, R8.7 (2), R8.8 (2), R9.2, SJ1.1, SJ3.2, SJ3.3, SJ4.1, U$2.2 (5V)
CE0: IC3.10 (CS), U$2.24 (CE0)
CH0: A0.I/O, R4.1
CH1: A1.I/O, R10.1
CH2: A2.I/O, R14.1
CH3: A3.I/O, R15.1
GND: A0.GND, A1.GND, A2.GND, A3.GND, C1.1, C2.1, C3.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, GPIO4.GND, GPIO5.GND, GPIO6.GND, GPIO12.GND, GPIO13.GND, GPIO16.GND, I2C0.GND, I2C1.GND, I2C2.GND, IC1.1 (GND), IC2.11 (GND), IC3.9 (DGND), IC3.14 (AGND), PWM0.GND, PWM1.GND, PWM2.GND, PWM3.GND, R1.1, R1.2 (1), R1.3 (1), R1.4 (1), R2.1, R2.2 (1), R2.3 (1), R2.4 (1), R5.1, R11.1, R12.1, R13.1, R17.1, R18.1, SERIAL.GND, U1.2 (VLSS), U1.6 (D7), U1.7 (D6), U1.8 (D5), U1.9 (D4), U1.10 (D3), U1.14 (E/RD#), U1.15 (R/W#), U1.16 (D/C#), U1.18 (CS#), U1.19 (BS2), U1.21 (BS0), U1.23 (VSS), U$2.9 (GND), U$2.14 (GND), U$2.20 (GND), U$2.25 (GND), U$2.30 (GND), U$2.34 (GND), U$2.39 (GND), U$9.14 (VSS)
GPIO4: IC2.1 (A1), U$2.7 (GPIO4)
GPIO5: IC2.3 (A2), U$2.29 (GPIO5)
GPIO6: IC2.4 (A3), U$2.31 (GPIO6)
GPIO12: IC2.5 (A4), U$2.32 (GPIO12)
GPIO13: IC2.6 (A5), U$2.33 (GPIO13)
GPIO16: IC2.7 (A6), U$2.36 (GPIO16)
GPIO17: U$2.11 (GPIO17)
GPIO18: U$2.12 (GPIO18)
GPIO19: U$2.35 (GPIO19)
GPIO20: U$2.38 (GPIO20)
GPIO21: U$2.40 (GPIO21)
GPIO22: U$2.15 (GPIO22)
GPIO23: U$2.16 (GPIO23)
GPIO24: U$2.18 (GPIO24)
GPIO25: U$2.22 (GPIO25)
GPIO26: U$2.37 (GPIO26)
GPIO27: U$2.13 (GPIO27)
H_SCL: I2C0.SCL, I2C1.SCL, I2C2.SCL, IC1.6 (SCL2), R8.1
H_SDA: I2C0.SDA, I2C1.SDA, I2C2.SDA, IC1.5 (SDA2), R8.2 (1)
MISO: IC3.12 (DOUT), U$2.21 (MISO)
MOSI: IC3.11 (DIN), U$2.19 (MOSI)
unnamed: R3.1, U$9.6 (LED0)
unnamed: R3.2 (1), U$9.7 (LED1)
unnamed: R1.7 (2), U$9.1 (A0)
unnamed: R3.3 (1), U$9.8 (LED2)
unnamed: R3.4 (1), U$9.9 (LED3)
unnamed: R2.6 (2), U$9.23 (OE)
unnamed: R1.8 (2), U$9.25 (EXTCLK)
unnamed: GPIO4.I/O, IC2.20 (B1)
unnamed: R1.6 (2), U$9.2 (A1)
unnamed: R1.5 (2), U$9.3 (A2)
unnamed: R2.8 (2), U$9.4 (A3)
unnamed: R2.7 (2), U$9.5 (A4)
unnamed: C5.2, U1.27 (C1P)
unnamed: GPIO5.I/O, IC2.18 (B2)
unnamed: C5.1, U1.26 (C1N)
unnamed: GPIO6.I/O, IC2.17 (B3)
unnamed: GPIO12.I/O, IC2.16 (B4)
unnamed: C4.1, U1.28 (C2N)
unnamed: GPIO13.I/O, IC2.15 (B5)
unnamed: C4.2, U1.29 (C2P)
unnamed: GPIO16.I/O, IC2.14 (B6)
unnamed: R5.2, U1.5 (IREF)
unnamed: C1.2, U1.4 (VCOMH)
unnamed: C2.2, U1.3 (VCC)
unnamed: R6.1, U1.17 (RES#), U1.20 (BS1)
unnamed: C3.2, D1.ANODE, R6.2, R7.1
unnamed: IC2.10 (OE), R13.2, R16.1
unnamed: SERIAL.VCC, SJ1.2
unnamed: IC3.3 (CH2), R14.2, R17.2
unnamed: IC1.7 (VREF2), IC1.8 (EN), R9.1
unnamed: IC3.1 (CH0), R4.2, R11.2
unnamed: R2.5 (2), SJ2.1
unnamed: IC3.2 (CH1), R10.2, R12.2
unnamed: IC3.4 (CH3), R15.2, R18.2
NC1: U$2.4 (5V)
NC2: U$2.6 (GND)
PWM0: PWM0.I/O, R3.8 (2)
PWM1: PWM1.I/O, R3.7 (2)
PWM2: PWM2.I/O, R3.6 (2)
PWM3: PWM3.I/O, R3.5 (2)
RX: SERIAL.RX, U$2.10 (RX)
SCL: IC1.3 (SCL1), R8.3 (1), U1.13 (D0), U$2.5 (SCL), U$9.26 (SCL)
SCLK: IC3.13 (CLK), U$2.23 (SCLK)
SDA: IC1.4 (SDA1), R8.4 (1), U1.11 (D2), U1.12 (D1), U$2.3 (SDA), U$9.27 (SDA)
TX: SERIAL.TX, U$2.8 (TX)

Notes on the sheet:
1.0.11
Jetson Nano
PWM Controller
Address 0x60
1N4148
PIN HEADER
OLED
I2C (4pin 2mm pitch) x2
I2C
LEVEL CONVERTER
AnalogINPUT
GPIO
PWM
A/D Converter
※シリアルブリックに電源が必要な時は、SJ1をつなげます。
※FaBo Brickとの間には、電圧は５Vの通信となります。
※TXB0108に変更

Board: 2 copper layers, 77.7 x 44.6 mm, 64 parts (9 on the bottom side), 61 nets.

Other parts of the board:
U$3, U$4, U$5, U$6: MARK_POINT_3MM

## EAGLE design 0519_outin_jetson_nano/pcb/AgentKit/519_jetson_nano_020100.brd

Schematic: 519_jetson_nano_020100.sch

Parts:
0/ST, 1/TH: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
A1: CAPACITOR-OS-CON; F13
C1, C2, C3, C4, C5: 0.1uF; 0603-NARROW
C6, C7, C13, C14, C15, C19: 0.1uF; 0603
C8: 10uF; 0603
C9, C20: 15pF; 0603
C10: 1uF; 0603
C11, C12, C18: 4.7uF; 0603
C16: DNP; 0603
C17: 4.7uF 1KV; 0603
C21, C22: 47uF; 0603-NARROW
CN1, CN2, CN3, CN4, CN5: PIN_1X1-SMALL; PIN_1X1_SMALL
CN6: PIN-HEADER-SMT(1.27MM)2X5
D1, D24: PMEG6020AELR; SOD123W
D3: SR54F; SMBF
FB1, FB2: FERRITEBEADS; 0603
FULLCOLORLED: PIN_1X2
GPIO4, GPIO5,6: MODULAR-JACK-6P-RJ11_GPIO3; 7002-6PXC-X
I2C, I2C1: MODULAR-JACK-6P-RJ11_I2C; 7002-6PXC-X
I2S0(DAP4)1: MODULAR-JACK-6P-RJ11_I2S_MASTER; 7002-6PXC-X
IC1: PCA9306_SSOP; 8PIN-SSOP
IC2: PCA9685BSPCA9685BS; HVQFN28
JETSON_PWM: MODULAR-JACK-6P-RJ11_GPIO3; 7002-6PXC-X
JP1, JP2, JP3, JP4, JP5: PIN_1X1_NOLABEL
L1, L2: MAF1608F; 1608MM
LED0, LED1, LED2, LED3, LED4: WS2812B_NARROW
LED5, LED10, LED11, LED12: LED-0603; 0603
LED6: IR; LED_5MM
LED7, LED8, LED9: LED-5MM; LED_5MM
M1: MOSFET-N_FDN335N; SUPERSOT-3
M2: OSRB38C9AA
R1, R2, R3, R4: 180; 0603
R5, R10, R38, R39: 22; 0603
R6: 634K; 0603
R7: 220; EXBV8V
R8: 510(1/4W); R0805
R9: 0; 0603
R11, R12, R13: 220; 0603
R14, R22, R23: 10K; 0603
R15, R16, R19, R20, R24, R25, R28, R29, R30, R31, R36, R37: 5.1K; 0603
R17, R18: 100K; 0603
R21: 1K; 0603
R26: 100K1%; 0603
R27: 13.7K1%; 0603
R32, R33, R34: 330; 0603
R35: 200K; 0603
R43: 22K; 0603
R44: 51K; 0603
R45: DNF; 0603
RAD8: RA_D8; LED_5MM
RAD9: RA_D9; LED_5MM
RS: CSTNE16M0V53L00ZR0; 3-SMD
SPI1-0, SPI2-0, SPI2-1: MODULAR-JACK-6P-RJ11_SPI; 7002-6PXC-X
SW1: TACT-SWITCH-SMD_KMR2; KMR2
T3, T4: TBL004-508
U$11, U$12: AVRF060X100LT242; AVRF0X0X100LT_0603
U$13: MAX98357A,B; TQFN(16L3*3*0.75)
U$14: 2MMJUMPER_CROSS; PINHEAD2MM_CROSS
U$19: R7FA4M1AB3CFM; LQFP-64_RENESAS
U$22: 5077CR-16-SMC2-BK-TR
U$23: PRTR5V0U2X; SOT143B
U$28: 74LVC1G125; TSOP5(SOT753)
U$32: JETSON_NANOJETSON_NANO_OVERALL; JETSON_NANO_DEMENTION
UART2: MODULAR-JACK-6P-RJ11_SERIAL_M_USART; 7002-6PXC-X

Connections:
3DB: R17.2, U$14.2
5V: C12.2, C13.2, C14.2, C19.2, CN6.1, D1.1 (CATHODE), D24.1 (CATHODE), FB2.1, LED11.ANODE, LED12.ANODE, R1.2, R2.2, R3.2, R4.2, R15.2, R16.1, R19.1, R20.1, R26.1, R28.1, R35.1, R36.1, R37.1, R43.1, R44.1, RAD8.A (ANODE), RAD9.A (ANODE), U$19.4:VBATT, U$19.11:VCC, U$19.21:VCC_USB_LDO, U$19.39:VCC
15DB: R18.1, U$14.4
AREF: FB1.1, R15.1
CAN0_RX: JP1.1, U$19.46:P102
CAN0_TX: JP2.1, U$19.45:P103
DAC: JP5.1, U$19.53:P014
GAIN: U$13.2 (2:GAIN), U$14.1
GND: 0/ST.GND, 1/TH.GND, A1.CATHODE (-), C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, CN1.1, CN2.1, CN6.3, CN6.5, CN6.9, GPIO4.1 (1:GND), GPIO5,6.1 (1:GND), I2C.1 (1:GND), I2C1.1 (1:GND), I2S0(DAP4)1.1 (1:GND), IC1.1 (GND), IC2.1:A3 (A3), IC2.2:A4 (A4), IC2.11:VSS (VSS), IC2.20:OE (OE), IC2.21:A5 (A5), IC2.22:EXTCLK (EXTCLK), IC2.26:A0 (A0), IC2.27:A1 (A1), IC2.28:A2 (A2), IC2.29 (VSS), JETSON_PWM.1 (1:GND), LED0.3-VSS (VSS), LED1.3-VSS (VSS), LED2.3-VSS (VSS), LED3.3-VSS (VSS), LED4.3-VSS (VSS), LED5.CATHODE, M1.S, M2.2:GND (GND), R8.1, R14.2, R18.2, R25.2, R27.2, R29.2, R30.2, R31.2, R32.2, R44.2, RS.2:GND (2), SPI1-0.1 (1:GND), SPI2-0.1 (1:GND), SPI2-1.1 (1:GND), SW1.3, SW1.4, U$11.2, U$12.2, U$13.3 (3:GND), U$13.11 (11:GND), U$13.15 (15:GND), U$13.17 (EP), U$14.5, U$19.8:VSS, U$19.17:VSS_USB, U$19.40:VSS, U$19.57:AVSS0, U$22.A1,B12:GND (GND), U$22.B1,A12:GND (GND), U$28.1 (1:OE), U$28.3 (3:GND), U$32.9 (GND), U$32.14 (GND), U$32.20 (GND), U$32.25 (GND), U$32.30 (GND), U$32.34 (GND), U$32.39 (GND), UART2.1 (1:GND)
GPIO2/SDA1: I2C.5 (5:SDA), I2C1.5 (5:SDA), IC1.4 (SDA1), IC2.24:SDA (SDA), R23.1, U$32.3 (SDA)
GPIO3/SCL1: I2C.4 (4:SCL), I2C1.4 (4:SCL), IC1.3 (SCL1), IC2.23:SCL (SCL), R22.1, U$32.5 (SCL)
GPIO4/AUDIO_MCLK: GPIO4.5 (5:PIN-A), U$32.7 (GPIO4)
GPIO5/CAM_AF_EN: GPIO5,6.5 (5:PIN-A), U$32.29 (GPIO5)
GPIO6/GPIO_PZ0: GPIO5,6.6 (6:PIN-B), U$32.31 (GPIO6)
GPIO7/SPI1_CS1: U$32.26 (CE1)
GPIO8/SPI1_CS0: SPI1-0.5 (5:CS), U$32.24 (CE0)
GPIO9/SPI1_MISO: SPI1-0.4 (4:MISO), U$32.21 (MISO)
GPIO10/SPI1_MOSI: FULLCOLORLED.1, SPI1-0.6 (6:MOSI), U$32.19 (MOSI)
GPIO11/SPI1_SCLK: SPI1-0.2 (2:SCK), U$32.23 (SCLK)
GPIO12/LCD_BL_PWM: JETSON_PWM.5 (5:PIN-A), U$32.32 (GPIO12)
GPIO13/GPIO_PE6: JETSON_PWM.6 (6:PIN-B), U$32.33 (GPIO13)
GPIO14/TXD: U$32.8 (TX), UART2.5 (5:TX)
GPIO15/RXD: U$32.10 (RX), UART2.6 (6:RX)
GPIO16/UART2_CTS: U$32.36 (GPIO16), UART2.2 (2:CTS)
GPIO17/UART2_RTS: U$32.11 (GPIO17), UART2.4 (4:RTS)
GPIO18: R39.2, U$32.12 (GPIO18)
GPIO18/I2S0_SCLK: I2S0(DAP4)1.4 (4:I2S_SCLK), R39.1, U$13.16 (16:BLCK)
GPIO19: R38.1, U$32.35 (GPIO19)
GPIO19/I2S0_FS: I2S0(DAP4)1.2 (2:I2S_FS), R38.2, U$13.14 (14:LRCLK)
GPIO20: R5.2, U$32.38 (GPIO20)
GPIO20/I2S0_DIN: I2S0(DAP4)1.5 (5:I2S_DIN), R5.1
GPIO21: R10.2, U$32.40 (GPIO21)
GPIO21/I2S0_DOUT: R10.1, U$13.1 (1:DIN)
GPIO22/LCD_TE: U$32.15 (GPIO22)
GPIO23/SPI2_CS1: SPI2-1.5 (5:CS), U$32.16 (GPIO23)
GPIO24/SPI2_CS0: SPI2-0.5 (5:CS), U$32.18 (GPIO24)
GPIO25/SPI2_MISO: SPI2-0.4 (4:MISO), SPI2-1.4 (4:MISO), U$32.22 (GPIO25)
GPIO26/SPI2_MOSI: SPI2-0.6 (6:MOSI), SPI2-1.6 (6:MOSI), U$32.37 (GPIO26)
GPIO27/SPI2_SCK: SPI2-0.2 (2:SCK), SPI2-1.2 (2:SCK), U$32.13 (GPIO27)
I2C0_SCL: U$32.28 (ID_SC)
I2C0_SDA: U$32.27 (ID_SD)
IR_OUT: M2.1:OUT (OUT), U$19.64:P000
IR_TRANSFER: R13.1, U$19.42:P106
JETSON3V3: C15.2, IC1.2 (VREF1), IC2.25:VDD (VDD), R6.1, R8.2, R17.1, R22.2, R23.2, U$14.3, U$32.1 (3V3), U$32.17 (3V3)
JETSON 5V: A1.ANODE (+), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, CN3.1, D1.2 (ANODE), D3.ANODE, GPIO4.3 (3:VCC), GPIO5,6.3 (3:VCC), I2C.3 (3:VCC), I2C1.3 (3:VCC), I2S0(DAP4)1.3 (3:VCC), JETSON_PWM.3 (3:VCC), LED0.1-VDD (VDD), LED1.1-VDD (VDD), LED2.1-VDD (VDD), LED3.1-VDD (VDD), LED4.1-VDD (VDD), R21.2, SPI1-0.3 (3:VCC), SPI2-0.3 (3:VCC), SPI2-1.3 (3:VCC), U$13.7 (7:VDD), U$13.8 (8:VDD), U$28.5 (5:VCC), U$32.2 (5V), UART2.3 (3:VCC)
LED1(D8): R11.1, U$19.28:P304
LED2(D9): R12.1, U$19.29:P303
MONO: R6.2, U$13.4 (4:SD_MODE)
unnamed: LED0.2-DOUT (DOUT), LED1.4-DIN (DIN)
unnamed: LED6.A (ANODE), R1.1
unnamed: LED8.A (ANODE), R3.1
unnamed: LED9.A (ANODE), R4.1
unnamed: LED5.ANODE, R21.1
unnamed: LED1.2-DOUT (DOUT), LED2.4-DIN (DIN)
unnamed: IC2.4:LED1 (LED1), R7.1
unnamed: LED2.2-DOUT (DOUT), LED3.4-DIN (DIN)
unnamed: LED3.2-DOUT (DOUT), LED4.4-DIN (DIN)
unnamed: IC2.3:LED0 (LED0), R7.2 (1)
unnamed: LED6.K (CATHODE), LED7.K (CATHODE), LED8.K (CATHODE), LED9.K (CATHODE), M1.D
unnamed: 0/ST.I/O, R7.7 (2)
unnamed: 1/TH.I/O, R7.8 (2)
unnamed: M1.G, R13.2, R14.1
unnamed: LED0.4-DIN (DIN), R9.1, R45.1
unnamed: LED7.A (ANODE), R2.1
unnamed: R9.2, U$28.4 (4:Y)
unnamed: C9.2, RS.1:INPUT (1), U$19.9:P213/XTAL
unnamed: C10.2, FB1.2, U$19.59:P010/VREFH0
unnamed: C7.2, FB2.2, U$19.56:AVCC0
unnamed: C20.2, RS.3:OUTPUT (3), U$19.10:P212/EXTAL
unnamed: C11.2, U$19.5:VCL
unnamed: R16.2, U$19.27:P200
unnamed: R19.2, U$19.26:P201/MD
unnamed: R24.2, R25.1
unnamed: R20.2, R24.1, U$19.16:P407
unnamed: 0/ST.VCC, 1/TH.VCC, D3.CATHODE
unnamed: R26.2, R27.1, U$19.49:P500
unnamed: JP3.1, U$19.31:P301
unnamed: R30.1, U$22.B5:CC2 (CC2)
unnamed: R31.1, U$22.A5:CC1 (CC1)
unnamed: LED10.CATHODE, R32.1
unnamed: LED10.ANODE, U$19.36:P111
unnamed: R34.2, U$19.54:P013/VREFL
unnamed: R33.2, U$19.55:P012/VREFH
unnamed: LED11.CATHODE, R33.1
unnamed: LED12.CATHODE, R34.1
unnamed: IC1.7 (VREF2), IC1.8 (EN), R35.2
unnamed: C21.2, C22.2, M2.3:VCC (VCC), R43.2
unnamed: JP4.1, U$19.30:P302
unnamed: FULLCOLORLED.2, R45.2, U$28.2 (2:A)
unnamed: R12.2, RAD9.K (CATHODE)
unnamed: R11.2, RAD8.K (CATHODE)
NC: CN6.6
NC1: U$32.4 (5V)
NC2: U$32.6 (GND)
OUTN: L2.1, U$13.10 (10:OUTN)
OUTP: L1.1, U$13.9 (9:OUTP)
RA4_SCL_5V: IC1.6 (SCL2), R36.2, U$19.48:P100
RA4_SDA_5V: IC1.5 (SDA2), R37.2, U$19.47:P101
RESET: C16.2, CN6.10, R28.2, SW1.1, SW1.2, U$19.25:RES
SCII_RXD: CN6.7, U$19.51:P502
SCII_TXD: CN6.8, U$19.50:P501
SHILED: C17.2, R29.1, U$22.SHILED2, U$22.SHILED6 (SHILED2), U$23.1 (1:GND)
SP_MINUS: CN5.1, L2.2, T4.P$1, T4.P$2, U$12.1
SP_PLUS: CN4.1, L1.2, T3.P$1, T3.P$2, U$11.1
SWDCLK: CN6.4, U$19.32:P300/TCK/SWCLK (32:P300/SWCLK)
SWDIO: CN6.2, U$19.33:P108/TMS/SWDIO
USBLDO3V3: C18.2, U$19.20:VCC_USB
USB_DN: U$19.18:P915/USB_DM, U$22.A7:DN1 (DN1), U$22.B7:DN2 (DN2), U$23.2 (2:IO1)
USB_DP: U$19.19:P914/USB_DP, U$22.A6:DP1 (DP1), U$22.B6:DP2 (DP2), U$23.3 (3:IO2)
VBUS_5V2: D24.2 (ANODE), U$22.A4,B9:VBUS (VBUS), U$22.B4,A9:VBUS (VBUS), U$23.4 (4:VCC)

Notes on the sheet:
Revision
Jetson ORIN Nano 40Pin
Jetson Nano 40Pin Header
GPIO
Full Color SPI LED LEVEL SHIFT
初版 2022/07/11
1.2
I2C
I2C(2Port)
SERIAL
I2S INPUT(MIC)
I2S INTERNAL PCM Class D Amplifier(MONO)
1.0.2
AVRF060X100LT242
6dB
12dB
Open 9dB
MONO
lowPassFilter
NotchFilter,ESD Protection
SPEAKER TERMINAL
3dB
15dB
ServoControl/RC Contorl
PCA9685BS
TEST PIN
5V INLET
INTERNAL
SUBMCU
USB
I2C LEVEL TRANSLATOR
Jetson Nano
RA4M1
0/ST
1/TH
OSCON 1000uF
SWD CONNECTOR
SPI(For LCD)
MAFF1608
SPI2

Board: 2 copper layers, 81.6 x 134.0 mm, 129 parts (13 on the bottom side), 103 nets.

Other parts of the board:
U$17: LOGO_FABO_L
