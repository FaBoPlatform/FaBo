# Repository FaBoPlatform/FaBo

## EAGLE design 0119_reflector/PCB/119_reflector.brd

Parts:
J1: FABO_BRICK_3PIN
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R: LBR-127HLD
R1: 200; AXL-REGULAR
R2: 1K; AXL-REGULAR
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
GND: J1.GND, R.P$2 (2), R.P$3 (3)
I/O: J1.I/O, R.P$4 (4), R2.2
unnamed: R.P$1 (1), R1.1
VCC: J1.VCC, R1.2, R2.1

Notes on the sheet:
1.0.1
LBR-127HLD

Board: 2 copper layers, 25.4 x 33.0 mm, 6 parts (0 on the bottom side), 4 nets.

## EAGLE design 0120_button/PCB/120_button.brd

Parts:
J1: FABO_BRICK_3PIN
LOGO1: LOGO_FABO-M_BOTTOM; LOGO_FABO_M_BOTTOM
R1: 1K; AXL-REGULAR
S1: TACT-SWITCH-12MM; 1273HA-160G-G
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
GND: J1.GND, S1.1, S1.2
unnamed: J1.VCC, R1.1
unnamed: J1.I/O, R1.2, S1.3, S1.4

Notes on the sheet:
1.0.5

Board: 2 copper layers, 25.4 x 33.0 mm, 5 parts (0 on the bottom side), 3 nets.

## EAGLE design 0121_jinkan/PCB/121_jinkan.brd

Parts:
C1, C2: 0.1uF; 0603-NARROW
J1: FABO_BRICK_3PIN
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1: 51K; 0603
R2: 22K; 0603
R3: 4.7K; 0603
R4: 9.1K; 0603
R5: 1.2K; 0603
SJ1, SJ2: SMD-JUMPER-LSMD-JUMER_L; SMD-JUMPER-L
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
U$4: EKBM; EKMB
U$5: TRANSISTOR-NPN; SOT-23

Connections:
GND: C1.1, C2.1, J1.GND, R2.1, R4.1, U$4.GND, U$5.2 (E)
I/O: J1.I/O, R3.1, SJ1.1, SJ2.2, U$5.3 (C)
unnamed: R1.2, U$4.OUT
unnamed: C2.2, R1.1, R2.2, U$5.1 (B)
unnamed: R4.2, SJ1.2
unnamed: R5.1, SJ2.1
VCC: C1.2, J1.VCC, R3.2, R5.2, U$4.VDD

Notes on the sheet:
1.0.4
EKMC1601111 EKMC1603111
100uA
2SC3324
※Jetson Nano使用時は、SJ1オープン、SJ2ショート OUTPUT 3.3V出力は、SJ1ショート,SJ2 SJ2ショート それ以外は SJ1,SJ2ともにオープン

Board: 2 copper layers, 25.4 x 33.0 mm, 16 parts (12 on the bottom side), 7 nets.

Other parts of the board:
U$6, U$7: MARK_POINT_3MM

## EAGLE design 0121_jinkan/PCB/121_jinkan_5m.brd

Parts:
J1: FABO_BRICK_3PIN
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R2: 10K; 0603
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
U$4: EKBM; EKMB

Connections:
GND: J1.GND, R2.1, U$4.GND
I/O: J1.I/O, R2.2, U$4.OUT
VCC: J1.VCC, U$4.VDD

Notes on the sheet:
1.0.1
EKMC1601111

Board: 2 copper layers, 25.4 x 33.0 mm, 5 parts (0 on the bottom side), 3 nets.

## EAGLE design 0123_relay/PCB/123_relay.brd

Parts:
CN1: PIN_HEADER_1X3; PIN_1X3
D1: NRVS1MFL; SD-123F
FET: FDN335N; FDN335
J1: FABO_BRICK_3PIN-S03B-PASK-2_LONG; FABO_BRICK_3PIN_S03B-PASK-2_LONG
LED2, LED3: RED; 0603
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1: 47; 0603-NARROW
R4: 3.3k; 0603-NARROW
R5: 1.8k; 0603-NARROW
R6, R10: 10k; 0603-NARROW
R7: 1k; 0603-NARROW
R8: 0; 0603-NARROW
U4: TLP291A; 11-3C1
U$2: G2RL-1
U$3, U$4, U$5: TBL004-508
U$10: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
GND: FET.2:S (S), J1.GND, R4.1, R6.1, R7.1, R10.1
unnamed: CN1.2, J1.I/O, R5.1
unnamed: LED2.ANODE, U4.2 (C)
unnamed: R8.1, U4.4 (COL)
unnamed: U$2.4, U$4.P$1, U$4.P$2
unnamed: CN1.3, R4.2
unnamed: LED2.CATHODE, R5.2
unnamed: U$2.2, U$3.P$1, U$3.P$2
unnamed: D1.1 (ANODE), FET.3:D (D), U$2.5
unnamed: R1.1, R6.2, U4.3 (EMI)
unnamed: U$2.3, U$5.P$1, U$5.P$2
unnamed: LED3.CATHODE, R7.2
RELAY02: FET.1:G (G), R1.2, R10.2
VCC: D1.2 (CATHODE), J1.VCC, LED3.ANODE, R8.2, U4.1 (A), U$2.1

Notes on the sheet:
1.0.9
ノーマリーオープン
電源確認LED
リレーON確認LED
NRVS1MFL
ノーマリークローズ
コモン
G2RL-1
5V専用
i/O電圧レベルが3.3V のときは、2-3をつなぐ
TBL004-508

Board: 2 copper layers, 46.0 x 46.0 mm, 22 parts (0 on the bottom side), 14 nets.

Other parts of the board:
U$11, U$12: MARK_POINT_3MM

Notices in the files:
parts and their libraries:
FaBo-Template: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
