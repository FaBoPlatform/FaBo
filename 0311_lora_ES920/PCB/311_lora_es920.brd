# Repository FaBoPlatform/FaBo

## EAGLE design 0311_lora_ES920/PCB/311_lora_es920.brd

Parts:
C1: 0.1uF; 0603-NARROW
C4: 1uF; 0603-NARROW
C5: 0.01uF; 0603-NARROW
C6: 4.7uF; 0603-NARROW
CN1: SMD-CONN-5PIN-SM05B-PASS-1; SM05B-PASS-1
D1: CUS05F40
IC1: LP2985-33DBV; SOT-23-5
JP1: JP2E; JP2
LOGO1: LOGO_FABO-M_BOTTOM; LOGO_FABO_M_BOTTOM
R2, R9: 10k; 0603-NARROW
R7, R8: 470; 0603-NARROW
RESET: TACT-SWITCH-SMD_KMR2; KMR2
T0, T1: LED-0603; 0603
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: TPTP20R; TP20R
U1: ES920LR
U$3: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
U$8: PIN-HEADER-SMT(1.27MM)2X5

Connections:
3V3: C1.2, JP1.2, R2.2, R7.2, R8.2, R9.2, U1.2 (VCCRF), U1.13 (VCC), U$8.1
GND: C1.1, C4.1, C5.1, C6.1, CN1.1, IC1.2 (GND), RESET.3, RESET.4, U1.1 (GND), U1.26 (GND), U1.GND, U1.GND_PAD1 (GND1), U1.GND_PAD2 (GND2), U1.GND_PAD3 (GND3), U1.GND_PAD4 (GND4), U$8.3, U$8.5
LDO_3V: C6.2, IC1.5 (VOUT), JP1.1
unnamed: T1.CATHODE, U1.19 (PTE16/PCS)
unnamed: T0.CATHODE, U1.20 (PTE17/SCK)
unnamed: R7.1, T0.ANODE
unnamed: R8.1, T1.ANODE
unnamed: R9.1, U1.16 (PTC1/SW_INT)
unnamed: C5.2, IC1.4 (BYPASS)
unnamed: TP6.TP, U1.15 (PTA19)
unnamed: TP3.TP, U1.10 (PTB0/SCL)
unnamed: TP2.TP, U1.11 (PTB1/SDA)
unnamed: TP1.TP, U1.12 (PTE30/DACO)
unnamed: TP4.TP, U1.22 (PTE19/MISO)
unnamed: TP5.TP, U1.21 (PTE18/MOSI)
unnamed: TP7.TP, U1.14 (PTA18)
unnamed: C4.2, D1.C (CATHODE), IC1.1 (VIN), IC1.3 (ON/OFF)
RESETB: CN1.5, R2.1, RESET.1, RESET.2, TP8.TP, U1.24 (RESETB), U$8.10
RX: CN1.3, U1.8 (PTA2/TX)
SWD_CLK: U1.5 (PTA0/SWD_CLK), U$8.4
SWD_DIO: U1.6 (PTA3/SWD_DIO), U$8.2
TX: CN1.4, U1.9 (PTA1/RX)
VCC: CN1.2, D1.A (ANODE), JP1.3

Notes on the sheet:
1.0.0
Reset Button
Debug
※注意 Arduino UNO ５Vマイコンとは繋がないでください。

Board: 2 copper layers, 46.0 x 46.0 mm, 27 parts (1 on the bottom side), 23 nets.

## EAGLE design 0311_lora_ES920/PCB/faboblocks/311_lora_es920_faboblocks_Rev020002.brd

Parts:
3V3_TESTPAD: TPTP20R; TP20R
C1: 0.1uF; 0603-NARROW
C4: 1uF; 0603-NARROW
C5: 0.01uF; 0603-NARROW
C6: 4.7uF; 0603-NARROW
CON1_RJ11_SERIAL: MODULAR-JACK-6P-RJ11_SERIAL_S; 7002-6PXC-X
CON2_RJ11_GPIO: MODULAR-JACK-6P-RJ11_GPIO; 7002-6PXC-X
D1: CUS05F40
IC1: LP2985-33DBV; SOT-23-5
IC2: NPN-SMD; SOT23-3
LOGO1: LOGO_FABO-M_BOTTOM; LOGO_FABO_M_BOTTOM
R1, R2, R3, R4, R9: 10k; 0402
R5: 0; 0402
R7, R8: 1K; 0402
RESET: TACT-SWITCH-SMD_KMR2; KMR2
T0, T1: LED-0603; 0603
TP1, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP11: TPTP20R; TP20R
TP2: TPB1,27; B1,27
U2: ES920LR_MODULE; MODULE
U$3: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
U$5: SSSS213202
U$8: PIN-HEADER-SMT(1.27MM)2X5

Connections:
1:GND: CON2_RJ11_GPIO.1 (1:GND)
3:VCC: CON2_RJ11_GPIO.3 (3:VCC)
3V3: 3V3_TESTPAD.TP, C1.2, R1.2, R2.2, R3.2, R4.2, R5.2, R9.2, U2.2 (VCCRF), U2.13 (VCC), U$5.2, U$8.1
DACO: TP1.TP, U2.12 (PTE30/DACO)
GND: C1.1, C4.1, C5.1, C6.1, CON1_RJ11_SERIAL.1 (1:GND), IC1.2 (GND), IC2.2 (E), RESET.3, RESET.4, TP11.TP, U2.1 (GND), U2.26 (GND), U$8.3, U$8.5
LDO3V3: C6.2, IC1.5 (VOUT), U$5.1
MISO: TP4.TP, U2.22 (PTE19/MISO)
MOSI: TP5.TP, U2.21 (PTE18/MOSI)
unnamed: R5.1, R7.2, R8.2
unnamed: T1.CATHODE, U2.19 (PTE16/PCS)
unnamed: T0.CATHODE, U2.20 (PTE17/SCK)
unnamed: R7.1, T0.ANODE
unnamed: R8.1, T1.ANODE
unnamed: C5.2, IC1.4 (BYPASS)
unnamed: C4.2, D1.C (CATHODE), IC1.1 (VIN), IC1.3 (ON/OFF)
PTA18: TP7.TP, U2.14 (PTA18)
PTA19: TP6.TP, U2.15 (PTA19)
PTC1/SW_INT: CON2_RJ11_GPIO.6 (6:PIN-B), R9.1, TP9.TP, U2.16 (PTC1/SW_INT)
RESET: CON2_RJ11_GPIO.5 (5:PIN-A), IC2.1 (B)
RESETB: IC2.3 (C), R2.1, R4.1, RESET.1, RESET.2, TP8.TP, U2.24 (RESETB), U$8.10
RX: CON1_RJ11_SERIAL.5 (5:RX), R3.1, U2.9 (PTA1/RX)
SCL: TP3.TP, U2.10 (PTB0/SCL)
SDA: TP2.TP, U2.11 (PTB1/SDA)
SWD_CLK: U2.5 (PTA0/SWD_CLK), U$8.4
SWD_DIO: U2.6 (PTA3/SWD_DIO), U$8.2
TX: CON1_RJ11_SERIAL.6 (6:TX), R1.1, U2.8 (PTA2/TX)
VCC: CON1_RJ11_SERIAL.3 (3:VCC), D1.A (ANODE), U$5.3

Notes on the sheet:
2.0.2
Reset Button
Debug
SSSS213202
300mA

Board: 2 copper layers, 68.4 x 32.0 mm, 38 parts (18 on the bottom side), 25 nets.

Other parts of the board:
U$2, U$4: 4-1BLOCK

## EAGLE design 0312_lora_RAK811/PCB/312_lora_rak811.brd

Parts:
C1, C3, C5, C6, C7, C8: 0.1uF; 0603-NARROW
C2: 4.7uF; 0603-NARROW
C4: 10uF; 0603-NARROW
IC1: LP2985-33DBV; SOT-23-5
J1: FABO_BRICK_SERIAL-LONGER; FABO_BRICK_SERIAL_LONGER
L1: COIL-0603; 0603
LOGO1: LOGO_FABO-M_BOTTOM; LOGO_FABO_M_BOTTOM
Q1, Q2: BSS138; SOT23-3
R1, R2, R3, R4, R5, R6, R7: 10k; 0603-NARROW
RESET: TACT-SWITCH-SMD_KMR2; KMR2
TP10, TP11: TP-15
U$2: RAK811
U$3: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
U$8: PIN-HEADER-SMT(1.27MM)2X5
UF1: HIROSE-U.FL; HIROSE-UF.L

Connections:
3V3: C1.2, C2.2, C6.2, IC1.5 (VOUT), Q1.1 (G), Q2.1 (G), R1.2, R2.2, R3.2, R5.2, R7.2, U$2.11 (VCC), U$8.1
5V: C4.2, C5.2, IC1.1 (VIN), IC1.3 (ON/OFF), J1.VCC, R4.2, R6.2
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, IC1.2 (GND), J1.GND, RESET.3, RESET.4, U$2.1 (GND), U$2.12 (GND), U$2.21 (GND), U$2.28 (GND), U$2.30 (GND), U$2.31 (GND), U$2.32 (GND), U$2.34 (GND), U$8.3, U$8.5, UF1.GND@1 (GND), UF1.GND@2 (GND)
unnamed: C7.2, L1.2, U$2.33 (RF_OUT)
unnamed: C8.2, L1.1, UF1.SIG
RESETB: C3.2, R2.1, RESET.2, U$2.24 (RST), U$8.10
RX: Q2.2 (S), R5.1, TP10.1, U$2.7 (UART1_RX)
RX_LV: J1.RX, Q2.3 (D), R6.1
SWD_CLK: R7.1, U$2.13 (PA14), U$8.4
SWD_DIO: R1.1, U$2.10 (PA13), U$8.2
TX: Q1.2 (S), R3.1, TP11.1, U$2.6 (UART1_TX)
TX_LV: J1.TX, Q1.3 (D), R4.1

Notes on the sheet:
1.0.0A
Reset Button
Debug

Board: 2 copper layers, 27.9 x 55.9 mm, 28 parts (0 on the bottom side), 12 nets.

## EAGLE design 0314_ble_NRF52/PCB/314_ble_nrf52.brd

Parts:
C1: 1uF; 0603-NARROW
C4, C5: 12pf; 0603
CY1: CRYSTAL-ABS07; ABRACON-ABS07-32.768KHZ
IC1: LP2985-33DBV; SOT-23-5
J1: FABO_BRICK_SERIAL
LED: LED-0603; 0603
LOGO1: LOGO_FABO-M_BOTTOM; LOGO_FABO_M_BOTTOM
Q1, Q2: BSS138; SOT23-3
R1: RESISTOR-0603; 0603
R2: RESISTOR-0603-NARROW; 0603-NARROW
R3, R4, R5, R6: 10k; 0603-NARROW
RESET: TACT-SWITCH-SMD_KMR2; KMR2
TP10, TP11: TP-15
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM
U$4: RAYTAC-MDBT42
U$8: PIN-HEADER-SMT(1.27MM)2X5

Connections:
3V3: C1.2, IC1.5 (VOUT), Q1.1 (G), Q2.1 (G), R3.2, R5.2, U$8.1
5V: IC1.1 (VIN), IC1.3 (ON/OFF), J1.VCC, R4.2, R6.2
+3V3: U$4.11 (VDD1)
DCC: U$4.10 (DCC)
DEC4: U$4.9 (DEC4)
GND: C1.1, C4.1, C5.1, IC1.2 (GND), J1.GND, LED.CATHODE, R1.2, RESET.3, RESET.4, U$4.1 (GND1), U$4.12 (GND2), U$4.24 (GND3), U$4.39 (GND4), U$8.3, U$8.5, U$8.9
unnamed: LED.ANODE, R2.1
unnamed: C5.2, CY1.P$2, U$4.13 (P0.00/XL1)
unnamed: C4.2, CY1.P$1, U$4.14 (P0.01/XL2)
P0.02: U$4.15 (P0.02)
P0.03: U$4.16 (P0.03)
P0.04: U$4.17 (P0.04)
P0.05: U$4.18 (P0.05)
P0.06: U$4.19 (P0.06)
P0.07: U$4.20 (P0.07)
P0.08: U$4.21 (P0.08)
P0.09: U$4.22 (P0.09)
P0.10: U$4.23 (P0.10)
P0.11: U$4.25 (P0.11)
P0.14: U$4.28 (P0.14)
P0.15: U$4.29 (P0.15)
P0.16: U$4.30 (P0.16)
P0.17: U$4.31 (P0.17)
P0.18: U$4.32 (P0.18)
P0.19: U$4.33 (P0.19)
P0.20: U$4.34 (P0.20)
P0.22: U$4.38 (P0.22)
P0.23: U$4.41 (P0.23)
P0.24: U$4.40 (P0.24)
P0.25: U$4.2 (P0.25)
P0.26: U$4.3 (P0.26)
P0.27: U$4.4 (P0.27)
P0.28: U$4.5 (P0.28)
P0.29: U$4.6 (P0.29)
P0.30: U$4.7 (P0.30)
P0.31: U$4.8 (P0.31)
P0_18: R2.2
RESET: U$4.35 (P0.21/RESET), U$8.10
RX: J1.RX, Q2.3 (D), R6.1
RX_LV: Q2.2 (S), R5.1, TP10.1, U$4.26 (P0.12)
SWCLK: R1.1, U$4.36 (SWDCLK), U$8.4
SWDIO: RESET.2, U$4.37 (SWDIO), U$8.2
TX: J1.TX, Q1.3 (D), R4.1
TX_LV: Q1.2 (S), R3.1, TP11.1, U$4.27 (P0.13)

Notes on the sheet:
1.0.0A
BLE Module
Voltage Converter
FaBo Connector
Reset Button
Debug
LED

Board: 2 copper layers, 27.9 x 39.4 mm, 23 parts (2 on the bottom side), 13 nets.

Other parts of the board:
U$5: LOGO_FABO_S

Notices in the files:
parts and their libraries:
FaBo-Capacitor: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
