# Repository FaBoPlatform/FaBo

## EAGLE design 0402_led_ring/PCB/402_led_ring.brd

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12: 0.1uF; 0603
J1: FABO_BRICK_3PIN-S03B-PASK-2_LONG; FABO_BRICK_3PIN_S03B-PASK-2_LONG
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12: WS2812B
LOGO1: LOGO_FABO-M; LOGO_FABO_M
TP1: TP-10
U$2, U$3: SCREW-PAD-3MM; SCREWPAD_3MM
U$4: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
5V: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, J1.VCC, LED1.1 (VDD), LED2.1 (VDD), LED3.1 (VDD), LED4.1 (VDD), LED5.1 (VDD), LED6.1 (VDD), LED7.1 (VDD), LED8.1 (VDD), LED9.1 (VDD), LED10.1 (VDD), LED11.1 (VDD), LED12.1 (VDD)
DIN: J1.I/O, LED1.4 (DIN)
DOUT: LED6.2 (DOUT), LED7.4 (DIN)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, J1.GND, LED1.3 (VSS), LED2.3 (VSS), LED3.3 (VSS), LED4.3 (VSS), LED5.3 (VSS), LED6.3 (VSS), LED7.3 (VSS), LED8.3 (VSS), LED9.3 (VSS), LED10.3 (VSS), LED11.3 (VSS), LED12.3 (VSS)
unnamed: LED1.2 (DOUT), LED2.4 (DIN)
unnamed: LED2.2 (DOUT), LED3.4 (DIN)
unnamed: LED3.2 (DOUT), LED4.4 (DIN)
unnamed: LED4.2 (DOUT), LED5.4 (DIN)
unnamed: LED5.2 (DOUT), LED6.4 (DIN)
unnamed: LED7.2 (DOUT), LED8.4 (DIN)
unnamed: LED8.2 (DOUT), LED9.4 (DIN)
unnamed: LED9.2 (DOUT), LED10.4 (DIN)
unnamed: LED10.2 (DOUT), LED11.4 (DIN)
unnamed: LED11.2 (DOUT), LED12.4 (DIN)
unnamed: LED12.2 (DOUT), TP1.1

Notes on the sheet:
1.0.4

Board: 2 copper layers, 46.0 x 46.0 mm, 30 parts (2 on the bottom side), 15 nets.

## EAGLE design 0403_led_bar/PCB/403_led_bar.brd

Parts:
C1, C2, C3, C4: 0.1uF; 0603-NARROW
J1: FABO_BRICK_3PIN-S03B-PASK-2_LONG; FABO_BRICK_3PIN_S03B-PASK-2_LONG
LED1, LED2, LED3, LED4, LED5: WS2812B_NARROW
LOGO1: LOGO_FABO-M_BOTTOM; LOGO_FABO_M_BOTTOM
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
5V: C1.2, C2.2, C3.2, C4.2, J1.VCC, LED1.1-VDD (VDD), LED2.1-VDD (VDD), LED3.1-VDD (VDD), LED4.1-VDD (VDD), LED5.1-VDD (VDD)
GND: C1.1, C2.1, C3.1, C4.1, J1.GND, LED1.3-VSS (VSS), LED2.3-VSS (VSS), LED3.3-VSS (VSS), LED4.3-VSS (VSS), LED5.3-VSS (VSS)
IN: J1.I/O, LED1.4-DIN (DIN)
unnamed: LED1.2-DOUT (DOUT), LED2.4-DIN (DIN)
unnamed: LED2.2-DOUT (DOUT), LED3.4-DIN (DIN)
unnamed: LED3.2-DOUT (DOUT), LED4.4-DIN (DIN)
unnamed: LED4.2-DOUT (DOUT), LED5.4-DIN (DIN)

Notes on the sheet:
1.0.4

Board: 2 copper layers, 49.5 x 8.9 mm, 12 parts (0 on the bottom side), 7 nets.

## EAGLE design 0404_led_matrix/PCB/404_led_matrix.brd

Parts:
C1, C2, C3, C4, C5, C6, C7, C9, C10, C11, C12, C13, C14, C15, C17, C18, C19, C20, C21, C22, C23, C25, C26, C27, C28, C29, C30, C31, C33, C34, C35, C36, C37, C38, C39, C41, C42, C43, C44, C45, C46, C47, C49, C50, C51, C52, C53, C54, C55, C57, C58, C59, C60, C61, C62, C63: CAPACITOR-0603; 0603
HOLE1, HOLE2, HOLE3, HOLE4: SCREW-PAD-2.8MM; SCREWPAD_2.8MM
J1, J2: FABO_BRICK_3PIN-S03B-PASK-2; FABO_BRICK_3PIN_S03B-PASK-2
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED30, LED31, LED32, LED33, LED34, LED35, LED36, LED37, LED38, LED39, LED40, LED41, LED42, LED43, LED44, LED45, LED46, LED47, LED48, LED49, LED50, LED51, LED52, LED53, LED54, LED55, LED56, LED57, LED58, LED59, LED60, LED61, LED62, LED63, LED64: WS2812B_NARROW
LOGO1: LOGO_FABO-L_BOTTOM; LOGO_FABO_L_BOTTOM
U$1: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
5V: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, J1.VCC, J2.VCC, LED1.1-VDD (VDD), LED2.1-VDD (VDD), LED3.1-VDD (VDD), LED4.1-VDD (VDD), LED5.1-VDD (VDD), LED6.1-VDD (VDD), LED7.1-VDD (VDD), LED8.1-VDD (VDD), LED9.1-VDD (VDD), LED10.1-VDD (VDD), LED11.1-VDD (VDD), LED12.1-VDD (VDD), LED13.1-VDD (VDD), LED14.1-VDD (VDD), LED15.1-VDD (VDD), LED16.1-VDD (VDD), LED17.1-VDD (VDD), LED18.1-VDD (VDD), LED19.1-VDD (VDD), LED20.1-VDD (VDD), LED21.1-VDD (VDD), LED22.1-VDD (VDD), LED23.1-VDD (VDD), LED24.1-VDD (VDD), LED25.1-VDD (VDD), LED26.1-VDD (VDD), LED27.1-VDD (VDD), LED28.1-VDD (VDD), LED29.1-VDD (VDD), LED30.1-VDD (VDD), LED31.1-VDD (VDD), LED32.1-VDD (VDD), LED33.1-VDD (VDD), LED34.1-VDD (VDD), LED35.1-VDD (VDD), LED36.1-VDD (VDD), LED37.1-VDD (VDD), LED38.1-VDD (VDD), LED39.1-VDD (VDD), LED40.1-VDD (VDD), LED41.1-VDD (VDD), LED42.1-VDD (VDD), LED43.1-VDD (VDD), LED44.1-VDD (VDD), LED45.1-VDD (VDD), LED46.1-VDD (VDD), LED47.1-VDD (VDD), LED48.1-VDD (VDD), LED49.1-VDD (VDD), LED50.1-VDD (VDD), LED51.1-VDD (VDD), LED52.1-VDD (VDD), LED53.1-VDD (VDD), LED54.1-VDD (VDD), LED55.1-VDD (VDD), LED56.1-VDD (VDD), LED57.1-VDD (VDD), LED58.1-VDD (VDD), LED59.1-VDD (VDD), LED60.1-VDD (VDD), LED61.1-VDD (VDD), LED62.1-VDD (VDD), LED63.1-VDD (VDD), LED64.1-VDD (VDD)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C57.1, C58.1, C59.1, C60.1, C61.1, C62.1, C63.1, J1.GND, J2.GND, LED1.3-VSS (VSS), LED2.3-VSS (VSS), LED3.3-VSS (VSS), LED4.3-VSS (VSS), LED5.3-VSS (VSS), LED6.3-VSS (VSS), LED7.3-VSS (VSS), LED8.3-VSS (VSS), LED9.3-VSS (VSS), LED10.3-VSS (VSS), LED11.3-VSS (VSS), LED12.3-VSS (VSS), LED13.3-VSS (VSS), LED14.3-VSS (VSS), LED15.3-VSS (VSS), LED16.3-VSS (VSS), LED17.3-VSS (VSS), LED18.3-VSS (VSS), LED19.3-VSS (VSS), LED20.3-VSS (VSS), LED21.3-VSS (VSS), LED22.3-VSS (VSS), LED23.3-VSS (VSS), LED24.3-VSS (VSS), LED25.3-VSS (VSS), LED26.3-VSS (VSS), LED27.3-VSS (VSS), LED28.3-VSS (VSS), LED29.3-VSS (VSS), LED30.3-VSS (VSS), LED31.3-VSS (VSS), LED32.3-VSS (VSS), LED33.3-VSS (VSS), LED34.3-VSS (VSS), LED35.3-VSS (VSS), LED36.3-VSS (VSS), LED37.3-VSS (VSS), LED38.3-VSS (VSS), LED39.3-VSS (VSS), LED40.3-VSS (VSS), LED41.3-VSS (VSS), LED42.3-VSS (VSS), LED43.3-VSS (VSS), LED44.3-VSS (VSS), LED45.3-VSS (VSS), LED46.3-VSS (VSS), LED47.3-VSS (VSS), LED48.3-VSS (VSS), LED49.3-VSS (VSS), LED50.3-VSS (VSS), LED51.3-VSS (VSS), LED52.3-VSS (VSS), LED53.3-VSS (VSS), LED54.3-VSS (VSS), LED55.3-VSS (VSS), LED56.3-VSS (VSS), LED57.3-VSS (VSS), LED58.3-VSS (VSS), LED59.3-VSS (VSS), LED60.3-VSS (VSS), LED61.3-VSS (VSS), LED62.3-VSS (VSS), LED63.3-VSS (VSS), LED64.3-VSS (VSS)
IN: J1.I/O, LED1.4-DIN (DIN)
unnamed: LED3.2-DOUT (DOUT), LED4.4-DIN (DIN)
unnamed: LED4.2-DOUT (DOUT), LED5.4-DIN (DIN)
unnamed: LED5.2-DOUT (DOUT), LED6.4-DIN (DIN)
unnamed: LED6.2-DOUT (DOUT), LED7.4-DIN (DIN)
unnamed: LED1.2-DOUT (DOUT), LED2.4-DIN (DIN)
unnamed: LED7.2-DOUT (DOUT), LED8.4-DIN (DIN)
unnamed: LED9.2-DOUT (DOUT), LED10.4-DIN (DIN)
unnamed: LED10.2-DOUT (DOUT), LED11.4-DIN (DIN)
unnamed: LED11.2-DOUT (DOUT), LED12.4-DIN (DIN)
unnamed: LED12.2-DOUT (DOUT), LED13.4-DIN (DIN)
unnamed: LED13.2-DOUT (DOUT), LED14.4-DIN (DIN)
unnamed: LED14.2-DOUT (DOUT), LED15.4-DIN (DIN)
unnamed: LED15.2-DOUT (DOUT), LED16.4-DIN (DIN)
unnamed: LED17.2-DOUT (DOUT), LED18.4-DIN (DIN)
unnamed: LED18.2-DOUT (DOUT), LED19.4-DIN (DIN)
unnamed: LED19.2-DOUT (DOUT), LED20.4-DIN (DIN)
unnamed: LED20.2-DOUT (DOUT), LED21.4-DIN (DIN)
unnamed: LED21.2-DOUT (DOUT), LED22.4-DIN (DIN)
unnamed: LED22.2-DOUT (DOUT), LED23.4-DIN (DIN)
unnamed: LED23.2-DOUT (DOUT), LED24.4-DIN (DIN)
unnamed: LED25.2-DOUT (DOUT), LED26.4-DIN (DIN)
unnamed: LED26.2-DOUT (DOUT), LED27.4-DIN (DIN)
unnamed: LED27.2-DOUT (DOUT), LED28.4-DIN (DIN)
unnamed: LED28.2-DOUT (DOUT), LED29.4-DIN (DIN)
unnamed: LED29.2-DOUT (DOUT), LED30.4-DIN (DIN)
unnamed: LED30.2-DOUT (DOUT), LED31.4-DIN (DIN)
unnamed: LED31.2-DOUT (DOUT), LED32.4-DIN (DIN)
unnamed: LED33.2-DOUT (DOUT), LED34.4-DIN (DIN)
unnamed: LED34.2-DOUT (DOUT), LED35.4-DIN (DIN)
unnamed: LED35.2-DOUT (DOUT), LED36.4-DIN (DIN)
unnamed: LED36.2-DOUT (DOUT), LED37.4-DIN (DIN)
unnamed: LED37.2-DOUT (DOUT), LED38.4-DIN (DIN)
unnamed: LED38.2-DOUT (DOUT), LED39.4-DIN (DIN)
unnamed: LED39.2-DOUT (DOUT), LED40.4-DIN (DIN)
unnamed: LED41.2-DOUT (DOUT), LED42.4-DIN (DIN)
unnamed: LED42.2-DOUT (DOUT), LED43.4-DIN (DIN)
unnamed: LED43.2-DOUT (DOUT), LED44.4-DIN (DIN)
unnamed: LED44.2-DOUT (DOUT), LED45.4-DIN (DIN)
unnamed: LED45.2-DOUT (DOUT), LED46.4-DIN (DIN)
unnamed: LED46.2-DOUT (DOUT), LED47.4-DIN (DIN)
unnamed: LED47.2-DOUT (DOUT), LED48.4-DIN (DIN)
unnamed: LED49.2-DOUT (DOUT), LED50.4-DIN (DIN)
unnamed: LED50.2-DOUT (DOUT), LED51.4-DIN (DIN)
unnamed: LED51.2-DOUT (DOUT), LED52.4-DIN (DIN)
unnamed: LED52.2-DOUT (DOUT), LED53.4-DIN (DIN)
unnamed: LED53.2-DOUT (DOUT), LED54.4-DIN (DIN)
unnamed: LED54.2-DOUT (DOUT), LED55.4-DIN (DIN)
unnamed: LED55.2-DOUT (DOUT), LED56.4-DIN (DIN)
unnamed: LED57.2-DOUT (DOUT), LED58.4-DIN (DIN)
unnamed: LED58.2-DOUT (DOUT), LED59.4-DIN (DIN)
unnamed: LED59.2-DOUT (DOUT), LED60.4-DIN (DIN)
unnamed: LED60.2-DOUT (DOUT), LED61.4-DIN (DIN)
unnamed: LED61.2-DOUT (DOUT), LED62.4-DIN (DIN)
unnamed: LED62.2-DOUT (DOUT), LED63.4-DIN (DIN)
unnamed: LED63.2-DOUT (DOUT), LED64.4-DIN (DIN)
unnamed: LED2.2-DOUT (DOUT), LED3.4-DIN (DIN)
NET1: LED8.2-DOUT (DOUT), LED9.4-DIN (DIN)
NET2: LED16.2-DOUT (DOUT), LED17.4-DIN (DIN)
NET3: LED24.2-DOUT (DOUT), LED25.4-DIN (DIN)
NET4: LED32.2-DOUT (DOUT), LED33.4-DIN (DIN)
NET5: LED40.2-DOUT (DOUT), LED41.4-DIN (DIN)
NET6: LED48.2-DOUT (DOUT), LED49.4-DIN (DIN)
NET7: LED56.2-DOUT (DOUT), LED57.4-DIN (DIN)
OUT: J2.I/O, LED64.2-DOUT (DOUT)

Notes on the sheet:
1.0.1
Title: 404_led_matrix
REV:
Released under the Creative Commons Attribution-ShareAlike 4.0 License https://creativecommons.org/licenses/by-sa/4.0/

Board: 2 copper layers, 71.0 x 71.0 mm, 129 parts (2 on the bottom side), 67 nets.

Other parts of the board:
U$2: LOGO_FABO_S

## EAGLE design 0405_led_jetracer/PCB/405_led_jetracer.brd

Parts:
LED1, LED2, LED3, LED4, LED5, LED6: APA102_IPIXEL; APA102_2020
LOGO1: LOGO_OSHW-S_BOTTOM; LOGO_OSHW_S_BOTTOM
LOGO2: LOGO_FABO-S; LOGO_FABO_S
SPI: FABO-SPI-LED-B04B; SPI-B04B-PASK-1

Connections:
5V: LED1.VCC, LED2.VCC, LED3.VCC, LED4.VCC, LED5.VCC, LED6.VCC, SPI.VCC
CI: LED1.CKI, SPI.CI
CI1: LED1.CKO, LED2.CKI
CI2: LED2.CKO, LED3.CKI
CI3: LED3.CKO, LED4.CKI
CI4: LED4.CKO, LED5.CKI
CI5: LED5.CKO, LED6.CKI
DI: LED1.SDI, SPI.DI
DI1: LED1.SDO, LED2.SDI
DI2: LED2.SDO, LED3.SDI
DI3: LED3.SDO, LED4.SDI
DI4: LED4.SDO, LED5.SDI
DI5: LED5.SDO, LED6.SDI
GND: LED1.GND, LED2.GND, LED3.GND, LED4.GND, LED5.GND, LED6.GND, SPI.GND

Notes on the sheet:
1.0.1

Board: 2 copper layers, 40.0 x 17.0 mm, 9 parts (1 on the bottom side), 14 nets.

## EAGLE design 0405_led_jetracer/PCB/405_led_jetracer010002.brd

Parts:
LED1, LED2, LED3: APA102_IPIXEL; APA102_2020
LOGO1: LOGO_OSHW-S_BOTTOM; LOGO_OSHW_S_BOTTOM
LOGO2: LOGO_FABO-S; LOGO_FABO_S
SPI_INPUT: FABO-SPI-LED-B04B; SPI-B04B-PASK-1
SPI_OUTPUT: FABO-SPI-LED-B04B; SPI-B04B-PASK-1

Connections:
5V: LED1.VCC, LED2.VCC, LED3.VCC, SPI_INPUT.VCC, SPI_OUTPUT.VCC
CI: LED1.CKI, SPI_INPUT.CI
CI1: LED1.CKO, LED2.CKI
CI2: LED2.CKO, LED3.CKI
CO: LED3.CKO, SPI_OUTPUT.CI
DI: LED1.SDI, SPI_INPUT.DI
DI1: LED1.SDO, LED2.SDI
DI2: LED2.SDO, LED3.SDI
DO: LED3.SDO, SPI_OUTPUT.DI
GND: LED1.GND, LED2.GND, LED3.GND, SPI_INPUT.GND, SPI_OUTPUT.GND

Notes on the sheet:
1.0.2
Rev 1.０.2 2024/02/07 変更点 カラーLEDの数を７個から３個 SPI延長ポート増設
Addtion
Reduction(From 7 to 3)

Board: 2 copper layers, 40.0 x 17.0 mm, 7 parts (2 on the bottom side), 10 nets.
