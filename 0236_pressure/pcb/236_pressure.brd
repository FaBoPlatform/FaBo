# Repository FaBoPlatform/FaBo

## EAGLE design 0236_pressure/pcb/236_pressure.brd

Parts:
C1: 1uF; EIA0603
C2: 0.1uF; 0603
C3: 0.1uF; EIA0603
IC1: LPS33HW
IC2: LP2985-33DBV; SOT-23-5
IC3: PCA9306GM; XQFN8
J1: FABO_BRICK_I2C
JP1: JUMPER-2_SMD; JUMPER-SMD-2
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1, R2: 4.7k; 0603
R3: 200k; 0603
R4: RESISTOR-0603; EIA0603
TP1: TP-15
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
3V3: C1.2, C3.2, IC1.1 (VDDIO), IC1.6 (CS), IC1.10 (VDD), IC2.5 (VOUT), IC3.2 (VREF1), JP1.1, R1.2, R2.2
5V: IC2.1 (VIN), IC2.3 (ON/OFF), J1.VCC, R3.2
ADRS: IC1.5 (SA0), JP1.2, R4.2
GND: C1.1, C2.1, C3.1, IC1.3 (RES), IC1.8 (GND), IC1.9 (GND), IC1.11 (GND), IC2.2 (GND), IC3.1 (GND), J1.GND, R4.1
unnamed: C2.2, IC3.7 (VREF2), IC3.8 (EN), R3.1
unnamed: IC1.7 (INT), TP1.1
SCL: IC1.2 (SCL), IC3.3 (SCL1), R1.1
SCL_HV: IC3.6 (SCL2), J1.SCL
SDA: IC1.4 (SDA), IC3.4 (SDA1), R2.1
SDA_HV: IC3.5 (SDA2), J1.SDA

Notes on the sheet:
1.0.0 Beta
I2C address Default: 0x5C JP1 short: 0x5D

Board: 2 copper layers, 27.9 x 39.4 mm, 15 parts (2 on the bottom side), 10 nets.

## EAGLE design 0238_powermeasure/pcb/238_power measure.brd

Parts:
ALARM1: RED; 0603
C1: 2.2uF; 0603
C2, C15, C16: 0.1uF; 0603
C10: 1uF; 0603
C14: 0.01uF; 0603
D2: 1N4148; 1N4148W
IC1: LP2985-33; SOT-23-5
J1: FABO_BRICK_I2C-S04B-PASK-2; FABO_BRICK_I2C_S04B-PASK-2
R1, R2: 4.7k; 0603
R3: 200k; 0603
R11: 0; 0603
R26: 4.7KΩ; 0603
R27, R28: 3.3Ω; 0603
R29: 510Ω; 0603
S2: 219-08J; CTS-219-08J
SHUNT1: WSL2512; 2512INCH
SJ1: SJ2W; SJ_2
T2: MUN2111T1-PNP_DRIVER-SC59-BEC; SC59-BEC
TP1, TP2, TP5: TP-15
U3: TI-INA226
U4: PCA9306DP1; TSSOP8
U$23, U$24, U$25: ML-1400-S1

Connections:
3V3: C1.2, C15.2, IC1.5 (VOUT), R1.2, R2.2, R26.2, S2.11, S2.15, SJ1.3, T2.E, TP5.1, U3.6 (VS+), U4.VREF1
5V: D2.ANODE, J1.VCC, SJ1.1
A0: S2.1, S2.2, S2.3, S2.4, U3.2 (A0)
A1: S2.5, S2.6, S2.7, S2.8, U3.1 (A1)
GND: ALARM1.CATHODE, C1.1, C2.1, C10.1, C14.1, C15.1, IC1.2 (GND), J1.GND, S2.12, S2.16, TP1.1, U3.7 (GND), U4.GND, U$25.LEFT1 (PIN1), U$25.LEFT2 (PIN1), U$25.RIGHT1 (PIN2), U$25.RIGHT2 (PIN2)
unnamed: C2.2, R3.1, TP2.1, U4.EN, U4.VREF2
unnamed: R3.2, SJ1.2
unnamed: IC1.3 (ON/OFF), R11.1
unnamed: C16.2, R27.1, U3.9 (VIN-)
unnamed: C16.1, R28.1, U3.10 (VIN+)
unnamed: R26.1, T2.B, U3.3 (ALERT)
unnamed: ALARM1.ANODE, R29.1
unnamed: R29.2, T2.C
unnamed: C14.2, IC1.4 (BYPASS)
unnamed: U3.8 (VBUS), U$23.LEFT1 (PIN1), U$23.LEFT2 (PIN1), U$23.RIGHT1 (PIN2), U$23.RIGHT2 (PIN2)
unnamed: C10.2, D2.CATHODE, IC1.1 (VIN), R11.2
SCL: R1.1, S2.9, S2.13, U3.5 (SCL), U4.SCL1
SCL_HV: J1.SCL, U4.SCL2
SDA: R2.1, S2.10, S2.14, U3.4 (SDA), U4.SDA1
SDA_HV: J1.SDA, U4.SDA2
VIN+: R28.2, SHUNT1.P$1 (1), U$24.LEFT1 (PIN1), U$24.LEFT2 (PIN1)
VIN-: R27.2, SHUNT1.P$2 (2), U$24.RIGHT1 (PIN2), U$24.RIGHT2 (PIN2)

Notes on the sheet:
1.0.1
MUN2111T1G
One of the switches 1 to 4, one of 5 to 8 can be turned on.
※ハイサイド測定時はジャンパ線などでつなぎます。
電源プラスへ
被試験体へ
被試験体のグランドへ接続
被試験体
※ローサイド測定時はジャンパ線などでつなぎます。
電源マイナスへ
※デバイスアドレス設定 A0,A1それぞれ１つONにする。 それぞれONしないと静電気により値が取得できないことがあるので注意。
※通信線電圧設定
※ハイサイド測定
※ローサイド測定
※デフォルト５V

Board: 2 copper layers, 46.0 x 46.0 mm, 35 parts (6 on the bottom side), 22 nets.

Other parts of the board:
U$1, U$3, U$4, U$5: MARK_POINT_3MM
U$14: LOGO_FABO_MS

## EAGLE design 0239_lux/pcb/239_lux.brd

Parts:
C1: 2.2uF; 0603
C2: 0.1uF; 0603
C3, C5: 1uF; 0603
C4: 0.01uF; 0603
IC1: TSL2591; TSL2591(SON)
IC2: LP2985-33DBV; SOT-23-5
IC3: PCA9306_SSOP; 8PIN-SSOP
J1: FABO_BRICK_I2C
JP1: INT; 1X01
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1, R2: 1.8k; 0603
R3: 200k; 0603
R4: 10k; 0603
TP1, TP2: TP-15
U$2: LOGO_OSHW-M_BOTTOM; LOGO_OSHW_M_BOTTOM

Connections:
5V: C5.2, IC2.1 (VIN), IC2.3 (ON/OFF), J1.VCC, R3.2
GND: C1.1, C2.1, C3.1, C4.1, C5.1, IC1.3 (GND), IC2.2 (GND), IC3.1 (GND), J1.GND
unnamed: C4.2, IC2.4 (BYPASS)
unnamed: C2.2, IC3.7 (VREF2), IC3.8 (EN), R3.1
unnamed: IC1.2 (INT), JP1.1, R4.1
SCL: IC1.1 (SCL), IC3.3 (SCL1), R1.1, TP2.1
SCL_HV: IC3.6 (SCL2), J1.SCL
SDA: IC1.6 (SDA), IC3.4 (SDA1), R2.1, TP1.1
SDA_HV: IC3.5 (SDA2), J1.SDA
VDD: C1.2, C3.2, IC1.5 (VDD), IC2.5 (VOUT), IC3.2 (VREF1), R1.2, R2.2, R4.2

Notes on the sheet:
1.0.0
LP2985-30
TSL2591

Board: 2 copper layers, 27.9 x 39.4 mm, 18 parts (2 on the bottom side), 10 nets.

Notices in the files:
parts and their libraries:
FaBo-Capacitor: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
