# Repository FaBoPlatform/FaBo (continued)

## EAGLE design 0529_agent_kit/0529_Agent_KitRev0103.brd

Parts:
C1, C2, C3, C4, C5: 0.1uF; 0603-NARROW
C6, C7, C10, C15, C16, C17: 0.1uF; 0603
C8: 10uF; 0603
C9, C21: MPFC-MINISIZE; DIP-MPFC
C11, C12, C13: DFN; 0603
C18, C19, C20: DNF; 0603
C100, C101: POLIYMER_MULTI_LAYER_MU; 4532
CN1, CN2, CN3, CN4, CN5: PIN_1X1-SMALL; PIN_1X1_SMALL
CON40: JETSON_NANOJETSON_ORIN_NANO; JETSON_ORIN_NANO_DIMENTION
GPIO5,6,22: MODULAR-JACK-6P-RJ11_GPIO3; 7002-6PXC-X
I2C: MODULAR-JACK-6P-RJ11_I2C; 7002-6PXC-X
I2S0(DAP4)1: MODULAR-JACK-6P-RJ11_I2S_MASTER; 7002-6PXC-X
IC2: PCA9685BSPCA9685BS; HVQFN28
L1, L2: VLS6045AF
L3, L4: VAF201610FA; VAF201610FA-1
LED0, LED1, LED2, LED3, LED4: WS2812B_NARROW
LED5: LED-0603; 0603
MIC_LEFT1: TDK-ICS43432
MIC_RIGHT1: TDK-ICS43432
R1, R9, R10, R11, R12, R13, R16: 0; 0603
R2, R3, R5: DNP; 0603
R4: 20K; 0603
R6: 634K; 0603
R7: 220; EXBV8V
R8: 510(1/4W); R0805
R14, R17, R18: 100K; 0603
R15, R19, R20: 0; 0402
R21: 1K; 0603
R22, R23: 10K; 0603
R24: 1M; 0603
SJ3: SMD-JUMPER-3-23SHORT; SMD-JUMPER-3
T3, T4: TBL004-508
U1: ADP3338AKCZ; SOT-223-KC3
U2: TXB0108; R-PUSON-N20
U$10, U$16: RC_3PIN_SERVO; PNHEADER_2.54_SMT_3PIN_RC_TT01_02
U$11, U$12: AVRF060X100LT242; AVRF0X0X100LT_0603
U$13: MAX98357A,B; TQFN(16L3*3*0.75)
U$14: 2MMJUMPER_CROSS; PINHEAD2MM_CROSS

Connections:
3DB: R17.2, U$14.2
3V3: C6.2, C8.2, C15.2, C101.P$1 (1), IC2.25:VDD (VDD), R6.1, R8.2, R17.1, U1.2 (OUT), U1.4 (OUT-TAB), U$13.7 (7:VDD), U$13.8 (8:VDD), U$14.3
15DB: R18.1, U$14.4
BCLK: C19.2, MIC_LEFT1.6 (SCK), MIC_RIGHT1.6 (SCK), R12.2
BCLK_98: C12.2, R10.2, U$13.16 (16:BLCK)
DATA: C18.2, MIC_LEFT1.7 (SD), MIC_RIGHT1.7 (SD), R13.2, R14.1
DATA_98: C11.2, R16.2, U$13.1 (1:DIN)
G6: GPIO5,6,22.5 (5:PIN-A), R1.2
GAIN: U$13.2 (2:GAIN), U$14.1
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.2, C8.1, C9.1, C10.2, C11.1, C12.1, C13.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C100.P$2 (2), C101.P$2 (2), CN1.1, CN2.1, CON40.9 (GND), CON40.14 (GND), CON40.20 (GND), CON40.25 (GND), CON40.30 (GND), CON40.34 (GND), CON40.39 (GND), GPIO5,6,22.1 (1:GND), I2C.1 (1:GND), I2S0(DAP4)1.1 (1:GND), IC2.1:A3 (A3), IC2.2:A4 (A4), IC2.11:VSS (VSS), IC2.20:OE (OE), IC2.21:A5 (A5), IC2.22:EXTCLK (EXTCLK), IC2.26:A0 (A0), IC2.27:A1 (A1), IC2.28:A2 (A2), IC2.29 (VSS), LED0.3-VSS (VSS), LED1.3-VSS (VSS), LED2.3-VSS (VSS), LED3.3-VSS (VSS), LED4.3-VSS (VSS), LED5.CATHODE, MIC_LEFT1.1 (LR), MIC_LEFT1.2 (CONFIG), MIC_LEFT1.4 (GND), MIC_RIGHT1.2 (CONFIG), MIC_RIGHT1.4 (GND), R2.2, R8.1, R14.2, R18.2, R24.1, U1.1 (GND), U2.11 (GND), U$10.3:GND3 (3:GND), U$11.2, U$12.2, U$13.3 (3:GND), U$13.11 (11:GND), U$13.15 (15:GND), U$13.17 (EP), U$14.5, U$16.3:GND3 (3:GND)
GPIO2/SDA1: CON40.3 (SDA), I2C.5 (5:SDA), IC2.24:SDA (SDA), R23.1
GPIO3/SCL1: CON40.5 (SCL), I2C.4 (4:SCL), IC2.23:SCL (SCL), R22.1
GPIO4/AUDIO_MCLK: CON40.7 (GPIO4)
GPIO5/CAM_AF_EN: CON40.29 (GPIO5)
GPIO6: R1.1, R2.1, R3.2, R5.2, U2.20 (B1)
GPIO6/GPIO_PZ0: CON40.31 (GPIO6), R5.1, U2.1 (A1)
GPIO7/SPI1_CS1: CON40.26 (CE1)
GPIO8/SPI1_CS0: CON40.24 (CE0)
GPIO9/SPI1_MISO: CON40.21 (MISO)
GPIO10/SPI1_MOSI: CON40.19 (MOSI), LED0.4-DIN (DIN)
GPIO11/SPI1_SCLK: CON40.23 (SCLK)
GPIO12/LCD_BL_PWM: CON40.32 (GPIO12)
GPIO13/GPIO_PE6: CON40.33 (GPIO13)
GPIO14/TXD: CON40.8 (TX)
GPIO15/RXD: CON40.10 (RX)
GPIO16/UART2_CTS: CON40.36 (GPIO16)
GPIO17/UART2_RTS: CON40.11 (GPIO17)
GPIO18/I2S0_SCLK: CON40.12 (GPIO18), R10.1, R12.1, R19.1
GPIO19/I2S0_FS: CON40.35 (GPIO19), R9.1, R11.1, R15.1
GPIO20/I2S0_DIN: CON40.38 (GPIO20), R13.1, R20.1
GPIO21/I2S0_DOUT: CON40.40 (GPIO21), R16.1
GPIO22/LCD_TE: CON40.15 (GPIO22)
GPIO23/SPI2_CS1: CON40.16 (GPIO23)
GPIO24/SPI2_CS0: CON40.18 (GPIO24)
GPIO25/SPI2_MISO: CON40.22 (GPIO25)
GPIO26/SPI2_MOSI: CON40.37 (GPIO26)
GPIO27/SPI2_SCK: CON40.13 (GPIO27)
I2C0_SCL: CON40.27 (ID_SC)
I2C0_SDA: CON40.28 (ID_SD)
JETSON3V3: C7.1, C16.2, C17.2, CON40.1 (3V3), CON40.17 (3V3), MIC_LEFT1.3 (VDD), MIC_RIGHT1.1 (LR), MIC_RIGHT1.3 (VDD), R3.1, R4.2, R22.2, R23.2, SJ3.1, U2.2 (VCCA)
JETSON 5V: C1.2, C2.2, C3.2, C4.2, C5.2, C10.1, C100.P$1 (1), CN3.1, CON40.2 (5V), GPIO5,6,22.3 (3:VCC), I2C.3 (3:VCC), I2S0(DAP4)1.3 (3:VCC), LED0.1-VDD (VDD), LED1.1-VDD (VDD), LED2.1-VDD (VDD), LED3.1-VDD (VDD), LED4.1-VDD (VDD), R21.2, SJ3.2, SJ3.3, U1.3 (IN), U2.19 (VCCB), U$10.2:VCC3 (2:VCC), U$16.2:VCC3 (2:VCC)
MONO: R6.2, U$13.4 (4:SD_MODE)
unnamed: LED0.2-DOUT (DOUT), LED1.4-DIN (DIN)
unnamed: I2S0(DAP4)1.2 (2:I2S_FS), R15.2
unnamed: I2S0(DAP4)1.4 (4:I2S_SCLK), R19.2
unnamed: I2S0(DAP4)1.5 (5:I2S_DIN), R20.2
unnamed: LED5.ANODE, R21.1
unnamed: LED1.2-DOUT (DOUT), LED2.4-DIN (DIN)
unnamed: IC2.4:LED1 (LED1), R7.1
unnamed: LED2.2-DOUT (DOUT), LED3.4-DIN (DIN)
unnamed: LED3.2-DOUT (DOUT), LED4.4-DIN (DIN)
unnamed: IC2.3:LED0 (LED0), R7.2 (1)
unnamed: R7.7 (2), U$10.1:SIGNAL3 (1:SIGNAL)
unnamed: R7.8 (2), U$16.1:SIGNAL3 (1:SIGNAL)
unnamed: R4.1, R24.2, U2.10 (OE)
NC1: CON40.4 (5V)
NC2: CON40.6 (GND)
OUTN: L2.1, U$13.10 (10:OUTN)
OUTP: L1.1, U$13.9 (9:OUTP)
SP_M: C9.2, L2.2, L4.1
SP_MINUS: CN5.1, L4.2, T4.P$1, T4.P$2, U$12.1
SP_P: C21.2, L1.2, L3.1
SP_PLUS: CN4.1, L3.2, T3.P$1, T3.P$2, U$11.1
WS: C20.2, MIC_LEFT1.5 (WS), MIC_RIGHT1.5 (WS), R11.2
WS_98: C13.2, R9.2, U$13.14 (14:LRCLK)

Notes on the sheet:
Revision
Jetson ORIN Nano 40Pin
Jetson ORIN Nano 40Pin Header
GPIO i/o
Full Color SPI LED
初版 2022/08/12
1.2
I2C
GPIO LEVEL SHFITER
Rev1.1 GPIO6追加
Rev1.2 レベルシフト追加、SPIノイズ対策
I2S INPUT
I2S INTERNAL PCM Class D Amplifier
LEFT ICS43432
RIGHT ICS43432
LEFT channel
RIGHT channel
RJ11 I2S_CONNECTOR
1.0.2
22uH
AVRF060X100LT242
6dB
12dB
Open 9dB
MONO
16MU106MC44532 10uF/16V
lowPassFilter
NotchFilter,ESD Protection
GMS,LTE FILTER
SPEAKER TERMINAL
2200pF
3dB
15dB
ORIN
ServoControl
PCA9685BS
Audio Power Suppy
Rev1.3 サウンド入出力追加、サーボ制御（SG-90用）、レベルシフトの配線修正。
TEST PIN
5V INLET

Board: 2 copper layers, 79.0 x 100.0 mm, 80 parts (18 on the bottom side), 43 nets.

Other parts of the board:
U$17: LOGO_FABO_L

## EAGLE design 0601_motor/PCB/601_motor.brd

Parts:
A0, A1, A2, A3: FABO_BRICK_3PIN-S03B-PASK-2; FABO_BRICK_3PIN_S03B-PASK-2
C1: 100uf; 153CLV-0405
C2, C3, C5: 0.1uF; EIA0603
C4: 22uf; 153CLV-0405
D9, D10, D11: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
I2C: FABO_BRICK_I2C-S04B-PASK-2; FABO_BRICK_I2C_S04B-PASK-2
IC1, IC2: MOTOR-DRIVER-TA7291FG
MOTOR1, MOTOR2: W237-102
R1, R2: 4.7k; 0603
SERIAL: FABO_BRICK_SERIAL-S04B-PASK-2; FABO_BRICK_SERIAL_S04B-PASK-2
SJ1: CLOSE; SMD-JUMPER-2-CLOSE
SW1: RESET; DTS_6_V
U1: ARDUINO_UNO_R3_SHIELD-NOLABEL; ARDUINO_UNO_R3_NOLABEL
U$2: DCJACK-MJ179PH; MJ179PH
U$6: LOGO_OSHW-T_M; LOGO_OSHW_T_MS
U$7: LOGO_FABO-M; LOGO_FABO_MS

Connections:
3V3: U1.3V3
5V: A0.VCC, A1.VCC, A2.VCC, A3.VCC, C2.1, C3.1, C4.+, C5.1, D9.VCC, D10.VCC, D11.VCC, I2C.VCC, IC1.11 (VCC), IC2.11 (VCC), SERIAL.VCC, SJ1.1, U1.5V
A0: A0.I/O, U1.A0
A1: A1.I/O, U1.A1
A2: A2.I/O, U1.A2
A3: A3.I/O, U1.A3
D9: D9.I/O, U1.D9
D10: D10.I/O, U1.D10
D11: D11.I/O, U1.D11
D12: SERIAL.RX, U1.D12
D13: SERIAL.TX, U1.D13
GND: A0.GND, A1.GND, A2.GND, A3.GND, C1.-, C2.2, C3.2, C4.-, C5.2, D9.GND, D10.GND, D11.GND, I2C.GND, IC1.1 (GND), IC2.1 (GND), SERIAL.GND, SW1.1, U1.GND1, U1.GND2, U1.GND3, U$2.-@1 (-), U$2.-@2 (-)
M1_IN1: IC1.7 (IN1), U1.D2
M1_IN2: IC1.9 (IN2), U1.D4
M1_OUT1: IC1.4 (OUT1), MOTOR1.2
M1_OUT2: IC1.13 (OUT2), MOTOR1.1
M1_REF: IC1.5 (VREF), U1.D3
M2_IN1: IC2.7 (IN1), U1.D5
M2_IN2: IC2.9 (IN2), U1.D7
M2_OUT1: IC2.4 (OUT1), MOTOR2.2
M2_OUT2: IC2.13 (OUT2), MOTOR2.1
M2_REF: IC2.5 (VREF), U1.D6
unnamed: R1.2, R2.2, SJ1.2
RESET: SW1.4, U1.RESET
SCL: I2C.SCL, R2.1, U1.SCL
SDA: I2C.SDA, R1.1, U1.SDA
VS: C1.+, IC1.15 (VS), IC2.15 (VS), U1.VIN, U$2.+

Notes on the sheet:
1.0.1
I2C/Serial (4pin Side 2mm pitch)
DIGITAL (3pin Top 2mm pitch)
ANALOG (3pin Side 2mm pitch)
I2C Pull-Up

Board: 2 copper layers, 68.6 x 53.3 mm, 27 parts (0 on the bottom side), 26 nets.

Other parts of the board:
U$19: LOGO_SILK_GND

Notices in the files:
parts and their libraries:
FaBo-Resistors: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
