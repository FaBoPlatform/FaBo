# Repository FaBoPlatform/FaBo (continued)

## EAGLE design 0509_outin_jetson/pcb/509_outin_jetson.brd

Parts:
A0, A1, A2, A3: FABO_BRICK_3PIN-S03B-PASK-2; FABO_BRICK_3PIN_S03B-PASK-2
A4, A5, A6, A7: FABO_BRICK_3PIN-B03B-PASK-1; FABO_BRICK_3PIN_B03B-PASK-1
A8: CAPACITOR-ALUMIN_H13; H13
C1, C2, C9: 0.1uF; 0603
GPIO16, GPIO17: FABO_BRICK_3PIN-B03B-PASK-1; FABO_BRICK_3PIN_B03B-PASK-1
I2C1, I2C2, I2C3: FABO_BRICK_I2C-S04B-PASK-2; FABO_BRICK_I2C_S04B-PASK-2
I2S(IN), I2S(OUT): FABO_BRICK_I2SLONG; FABO_BRICK_I2S_S05B-PASK-2_LONG
IC1: MICROCHIP-MCP3008
LOGO1: LOGO_FABO-M; LOGO_FABO_M
P1: POLYSWITCHMF-NSML1; 1206
PWM0, PWM1, PWM2, PWM3, PWM4: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
R5, R6, R7, R8, R9: 220; 0603
R13, R17, R18, R19, R20, R21, R22: 10K; 0402
R16: 10K; 0603
SERIAL: FABO_BRICK_SERIAL-S04B-PASK-2; FABO_BRICK_SERIAL_S04B-PASK-2
SV1: MA20-2
U$4: LOGO_OSHW-T_M_BOTTOM; LOGO_OSHW_T_MS_BOTTOM
U$9: PCA9685
U$15: 4UCON-DC

Connections:
3V3: SV1.1, SV1.17
5V: A0.VCC, A1.VCC, A2.VCC, A3.VCC, A4.VCC, A5.VCC, A6.VCC, A7.VCC, C1.2, C9.2, GPIO16.VCC, GPIO17.VCC, I2C1.VCC, I2C2.VCC, I2C3.VCC, I2S(IN).VCC, I2S(OUT).VCC, IC1.15 (VREF), IC1.16 (VDD), SERIAL.VCC, SV1.2, SV1.4, U$9.28 (VDD)
CH0: A0.I/O, IC1.1 (CH0)
CH1: A1.I/O, IC1.2 (CH1)
CH2: A2.I/O, IC1.3 (CH2)
CH3: A3.I/O, IC1.4 (CH3)
CH4: A4.I/O, IC1.5 (CH4)
CH5: A5.I/O, IC1.6 (CH5)
CH6: A6.I/O, IC1.7 (CH6)
CH7: A7.I/O, IC1.8 (CH7)
CS0: IC1.10 (CS), SV1.24
GND: A0.GND, A1.GND, A2.GND, A3.GND, A4.GND, A5.GND, A6.GND, A7.GND, A8.MINUS (-), C1.1, C2.1, C9.1, GPIO16.GND, GPIO17.GND, I2C1.GND, I2C2.GND, I2C3.GND, I2S(IN).GND, I2S(OUT).GND, IC1.9 (DGND), IC1.14 (AGND), PWM0.GND, PWM1.GND, PWM2.GND, PWM3.GND, PWM4.GND, R13.P$1 (1), R16.1, R17.P$1 (1), R18.P$1 (1), R19.P$1 (1), R20.P$1 (1), R21.P$1 (1), R22.P$1 (1), SERIAL.GND, SV1.6, SV1.9, SV1.14, SV1.20, SV1.25, SV1.30, SV1.34, SV1.39, U$9.14 (VSS), U$15.GND1 (GND), U$15.GND2 (GNDBREAK)
GPIO16: GPIO16.I/O, SV1.22
GPIO17: GPIO17.I/O, SV1.15
I2S_SFSYNC: I2S(IN).WS, I2S(OUT).WS, SV1.35
I2S_SIN: I2S(IN).DATA, SV1.38
I2S_SOUT: I2S(OUT).DATA, SV1.40
I2S_SRCLK: I2S(IN).BCLK, I2S(OUT).BCLK, SV1.12
LED0: R5.1, U$9.6 (LED0)
LED1: R6.1, U$9.7 (LED1)
LED2: R7.1, U$9.8 (LED2)
LED3: R8.1, U$9.9 (LED3)
LED4: R9.1, U$9.10 (LED4)
MISO: IC1.12 (DOUT), SV1.21
MOSI: IC1.11 (DIN), SV1.19
unnamed: P1.P$1 (1), U$15.VCC (PWR)
unnamed: R16.2, U$9.23 (OE)
unnamed: R13.P$2 (2), U$9.25 (EXTCLK)
unnamed: R17.P$2 (2), U$9.1 (A0)
unnamed: R18.P$2 (2), U$9.2 (A1)
unnamed: R19.P$2 (2), U$9.3 (A2)
unnamed: R20.P$2 (2), U$9.4 (A3)
unnamed: R21.P$2 (2), U$9.5 (A4)
unnamed: R22.P$2 (2), U$9.24 (A5)
PWM0: PWM0.I/O, R5.2
PWM1: PWM1.I/O, R6.2
PWM2: PWM2.I/O, R7.2
PWM3: PWM3.I/O, R8.2
PWM4: PWM4.I/O, R9.2
RX: SERIAL.RX, SV1.10
SCL: I2C1.SCL, I2C2.SCL, I2C3.SCL, SV1.5, U$9.26 (SCL)
SCLK: IC1.13 (CLK), SV1.23
SDA: I2C1.SDA, I2C2.SDA, I2C3.SDA, SV1.3, U$9.27 (SDA)
TX: SERIAL.TX, SV1.8
VCC: A8.PLUS (+), C2.2, P1.P$2 (2), PWM0.VCC, PWM1.VCC, PWM2.VCC, PWM3.VCC, PWM4.VCC

Notes on the sheet:
1.0.0Beta3
I2C(4pin Side 2mm pitch) x3
Analog(3pin Side 2mm pitch) x4
Serial (4pin Side 2mm pitch)
GPIO (3pin Top 2mm pitch) x8
Analog(3pin Top 2mm pitch) x4
I2S (5pin Top 2.54mm pitch) x2
GPIO/Servo (3pin Top 2.54mm pitch) x5
VOLTAGE SUPPLY

Board: 2 copper layers, 85.1 x 52.3 mm, 49 parts (0 on the bottom side), 45 nets.

Other parts of the board:
U$2, U$5, U$6: LOGO_SILK_I2C
U$3: LOGO_SILK_SERIAL2

## EAGLE design 0509_outin_jetson/pcb/519_jetson_nano_107.brd

Parts:
A0, A1: FABO_BRICK_3PIN-S03B-PASK-2; FABO_BRICK_3PIN_S03B-PASK-2
ADC1: MICROCHIP-MCP3426
C1, C2, C3: 10uF; 0603-BOTTOM
C4, C5, C6, C7: 1uF; 0603-BOTTOM
C8, C9, C10, C11: 0.1uF; 0603
D1: 1N4148; 1N4148W
GPIO4, GPIO5, GPIO6, GPIO12, GPIO13, GPIO16: FABO_BRICK_3PIN-B03B-PASK-1; FABO_BRICK_3PIN_B03B-PASK-1
I2C0: FABO_BRICK_I2C-S04B-PASK-2; FABO_BRICK_I2C_S04B-PASK-2
I2C1, I2C2: FABO_BRICK_I2C-B04B-PASK-1; FABO_BRICK_I2C_B04B-PASK-1
IC1: PCA9306_SSOP; 8PIN-SSOP
IC2: TXS0108; R-PUSON-N20
PWM0, PWM1, PWM2, PWM3: FABO_BRICK_3PIN-HEADER; FABO_BRICK_3PIN_HEADER
R1, R2: 10k; EXBV8V
R3: 220; EXBV8V
R5: 390K; 0603-BOTTOM
R6: 100; 0603-BOTTOM
R7: 10K; 0603-BOTTOM
R8: 10K; EXBV8V
R9: 200K; 0603
R13: 100K; 0603-BOTTOM
SERIAL: FABO_BRICK_SERIAL-B04B-PASK-1; FABO_BRICK_SERIAL_B04B-PASK-1
SJ1: SJ2W; SJ_2
U1: ER-OLED0.96-1ER-CON30HT-1; ER-CON30HT-1
U$2: JETSON_NANO_WIDE
U$9: PCA9685
U$14: LOGO_FABO-M; LOGO_FABO_MS

Connections:
3V3: C6.2, C7.2, C8.2, C10.2, D1.CATHODE, IC1.2 (VREF1), IC2.2 (VCCA), IC2.10 (OE), R7.2, R8.5 (2), R8.6 (2), R13.2, SJ1.3, U1.22 (VDD), U1.25 (VBAT), U$2.1 (3V3), U$9.24 (A5), U$9.28 (VDD)
5V: A0.VCC, A1.VCC, ADC1.3 (VDD), C9.2, C11.1, GPIO4.VCC, GPIO5.VCC, GPIO6.VCC, GPIO12.VCC, GPIO13.VCC, GPIO16.VCC, I2C0.VCC, I2C1.VCC, I2C2.VCC, IC2.19 (VCCB), PWM0.VCC, PWM1.VCC, PWM2.VCC, PWM3.VCC, R8.7 (2), R8.8 (2), R9.2, SJ1.1, U$2.2 (5V)
CE0: U$2.24 (CE0)
CH0: A0.I/O, ADC1.1 (CH1+)
CH1: A1.I/O, ADC1.7 (CH2+)
GND: A0.GND, A1.GND, ADC1.2 (CH1-), ADC1.6 (VSS), ADC1.8 (CH2-), C1.1, C2.1, C3.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.2, GPIO4.GND, GPIO5.GND, GPIO6.GND, GPIO12.GND, GPIO13.GND, GPIO16.GND, I2C0.GND, I2C1.GND, I2C2.GND, IC1.1 (GND), IC2.11 (GND), PWM0.GND, PWM1.GND, PWM2.GND, PWM3.GND, R1.1, R1.2 (1), R1.3 (1), R1.4 (1), R2.1, R2.2 (1), R2.3 (1), R5.1, R13.1, SERIAL.GND, U1.2 (VLSS), U1.6 (D7), U1.7 (D6), U1.8 (D5), U1.9 (D4), U1.10 (D3), U1.14 (E/RD#), U1.15 (R/W#), U1.16 (D/C#), U1.18 (CS#), U1.19 (BS2), U1.21 (BS0), U1.23 (VSS), U$2.9 (GND), U$2.14 (GND), U$2.20 (GND), U$2.25 (GND), U$2.30 (GND), U$2.34 (GND), U$2.39 (GND), U$9.14 (VSS)
GPIO4: IC2.1 (A1), U$2.7 (GPIO4)
GPIO5: IC2.3 (A2), U$2.29 (GPIO5)
GPIO6: IC2.4 (A3), U$2.31 (GPIO6)
GPIO12: IC2.5 (A4), U$2.32 (GPIO12)
GPIO13: IC2.6 (A5), U$2.33 (GPIO13)
GPIO16: IC2.7 (A6), U$2.36 (GPIO16)
GPIO17: U$2.11 (GPIO17)
GPIO18: U$2.12 (GPIO18)
GPIO19: U$2.35 (GPIO19)
GPIO20: U$2.38 (GPIO20)
GPIO21: U$2.40 (GPIO21)
GPIO22: U$2.15 (GPIO22)
GPIO23: U$2.16 (GPIO23)
GPIO24: U$2.18 (GPIO24)
GPIO25: U$2.22 (GPIO25)
GPIO26: U$2.37 (GPIO26)
GPIO27: U$2.13 (GPIO27)
H_SCL: ADC1.5 (SCL), I2C0.SCL, I2C1.SCL, I2C2.SCL, IC1.6 (SCL2), R8.1
H_SDA: ADC1.4 (SDA), I2C0.SDA, I2C1.SDA, I2C2.SDA, IC1.5 (SDA2), R8.2 (1)
MISO: U$2.21 (MISO)
MOSI: U$2.19 (MOSI)
unnamed: R3.1, U$9.6 (LED0)
unnamed: R3.2 (1), U$9.7 (LED1)
unnamed: R1.7 (2), U$9.1 (A0)
unnamed: R3.3 (1), U$9.8 (LED2)
unnamed: R3.4 (1), U$9.9 (LED3)
unnamed: R2.6 (2), U$9.23 (OE)
unnamed: R1.8 (2), U$9.25 (EXTCLK)
unnamed: GPIO4.I/O, IC2.20 (B1)
unnamed: R1.6 (2), U$9.2 (A1)
unnamed: R1.5 (2), U$9.3 (A2)
unnamed: R2.8 (2), U$9.4 (A3)
unnamed: R2.7 (2), U$9.5 (A4)
unnamed: C5.2, U1.27 (C1P)
unnamed: GPIO5.I/O, IC2.18 (B2)
unnamed: C5.1, U1.26 (C1N)
unnamed: GPIO6.I/O, IC2.17 (B3)
unnamed: GPIO12.I/O, IC2.16 (B4)
unnamed: C4.1, U1.28 (C2N)
unnamed: GPIO13.I/O, IC2.15 (B5)
unnamed: C4.2, U1.29 (C2P)
unnamed: GPIO16.I/O, IC2.14 (B6)
unnamed: R5.2, U1.5 (IREF)
unnamed: C1.2, U1.4 (VCOMH)
unnamed: C2.2, U1.3 (VCC)
unnamed: R6.1, U1.17 (RES#), U1.20 (BS1)
unnamed: C3.2, D1.ANODE, R6.2, R7.1
unnamed: SERIAL.VCC, SJ1.2
unnamed: IC1.7 (VREF2), IC1.8 (EN), R9.1
PWM0: PWM0.I/O, R3.8 (2)
PWM1: PWM1.I/O, R3.7 (2)
PWM2: PWM2.I/O, R3.6 (2)
PWM3: PWM3.I/O, R3.5 (2)
RX: SERIAL.RX, U$2.10 (RX)
SCL: IC1.3 (SCL1), R8.3 (1), U1.13 (D0), U$2.5 (SCL), U$9.26 (SCL)
SCLK: U$2.23 (SCLK)
SDA: IC1.4 (SDA1), R8.4 (1), U1.11 (D2), U1.12 (D1), U$2.3 (SDA), U$9.27 (SDA)
TX: SERIAL.TX, U$2.8 (TX)

Notes on the sheet:
1.0.7
Jetson Nano
PWM Controller
Address 0x60
1N4148
PIN HEADER
OLED
I2C (4pin 2mm pitch) x2
I2C
Serial (4pin Side 2mm pitch)
LEVEL CONVERTER
AnalogINPUT
GPIO
PWM
A/D Converter
※ブリックに電源が必要な時は、SJ1をつなげます。

Board: 2 copper layers, 77.7 x 44.6 mm, 49 parts (6 on the bottom side), 49 nets.

Other parts of the board:
U$3, U$4, U$5, U$6: MARK_POINT_3MM

## EAGLE design 0510_health_arduino/PCB/510_health_arduino.brd

Parts:
A0, A1, A2, A3, A4, A5: FABO_BRICK_3PIN-S03B-PASK-2_LONG; FABO_BRICK_3PIN_S03B-PASK-2_LONG
C1, C2, C3, C4, C6, C9, C11: 1uF; 0603
C5, C7, C10, C12: 10uF; 0603
C8: 1nF; 0603
C13: 1000pF; 0603
C14, C15: 10pF; 0603
D2, D3, D4, D5, D6, D7: FABO_BRICK_3PIN-B03B-PASK-1; FABO_BRICK_3PIN_B03B-PASK-1
E1: MA-MAX30003; MAXIM-MAX30003
I2C_SIDE: FABO_BRICK_I2C-S04B-PASK-2_LONG; FABO_BRICK_I2C_S04B-PASK-2_LONG
I2C_TOP: FABO_BRICK_I2C-B04B-PASK-1; FABO_BRICK_I2C_B04B-PASK-1
IC1: AP2112K-1.8TRG1; SOT-23-5
LOGO1: LOGO_FABO-M; LOGO_FABO_M
R1, R2, R3, R4: 4.7K; 0603
S1: TACT-SWITCH-6MM; DTS_6_V
SERIAL_HW: FABO_BRICK_SERIAL-B04B-PASK-1; FABO_BRICK_SERIAL_B04B-PASK-1
SERIAL_SW: FABO_BRICK_SERIAL-B04B-PASK-1; FABO_BRICK_SERIAL_B04B-PASK-1
SJ1: CLOSE; SMD-JUMPER-0603
U$4: ML-1400-S1
U$13: LOGO_OSHW-T_M_BOTTOM; LOGO_OSHW_T_MS_BOTTOM
U$15: ARDUINO_UNO_R3_SPI

Connections:
1V8: C2.2, C3.2, C6.2, C7.2, E1.13 (DVDD), E1.22 (AVDD), IC1.5 (VOUT)
3V3: C4.2, C5.2, E1.19 (0VDD), U$15.3V3
5V: A0.VCC, A1.VCC, A2.VCC, A3.VCC, A4.VCC, A5.VCC, C1.2, D2.VCC, D3.VCC, D4.VCC, D5.VCC, D6.VCC, D7.VCC, I2C_SIDE.VCC, I2C_TOP.VCC, IC1.1 (VIN), SERIAL_HW.VCC, SERIAL_SW.VCC, SJ1.1, U$15.5V
A0: A0.I/O, U$15.A0
A1: A1.I/O, U$15.A1
A2: A2.I/O, U$15.A2
A3: A3.I/O, U$15.A3
A4/SDA: A4.I/O, U$15.A4
A5/SCL: A5.I/O, U$15.A5
D0: SERIAL_HW.RX, U$15.D0
D1: SERIAL_HW.TX, U$15.D1
D2: D2.I/O, U$15.D2
D3: D3.I/O, U$15.D3
D4: D4.I/O, U$15.D4
D5: D5.I/O, U$15.D5
D6: D6.I/O, U$15.D6
D7: D7.I/O, U$15.D7
D8: U$15.D8
D9: U$15.D9
D10: U$15.D10
D11: U$15.D11
D12: SERIAL_SW.RX, U$15.D12
D13: SERIAL_SW.TX, U$15.D13
GND: A0.GND, A1.GND, A2.GND, A3.GND, A4.GND, A5.GND, C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C10.1, C11.1, C12.1, C14.1, C15.1, D2.GND, D3.GND, D4.GND, D5.GND, D6.GND, D7.GND, E1.1 (IC), E1.2 (IC), E1.3 (AGND), E1.4 (IC), E1.5 (IC), E1.8 (AGND), E1.12 (DGND), E1.24 (IC), E1.26 (IC), E1.28 (AGND), E1.P$29 (EP), I2C_SIDE.GND, I2C_TOP.GND, IC1.2 (GND), S1.3, SERIAL_HW.GND, SERIAL_SW.GND, U$15.GND1 (GND), U$15.GND2 (GND), U$15.GND3 (GND), U$15.ICSP6 (GND)
INN: C13.1, C14.2, E1.7 (INN), R4.1
INP: C13.2, C15.2, E1.6 (INP), R3.1
MISO: E1.18 (SDO), U$15.ICSP1 (MISO)
MOSI: E1.17 (SDI), U$15.ICSP4 (MOSI)
unnamed: R1.2, R2.2, SJ1.2
unnamed: C9.2, E1.9 (CAPP)
unnamed: C9.1, E1.10 (CAPN)
unnamed: C8.2, E1.11 (CPLL)
unnamed: R3.2, U$4.LEFT1 (PIN1), U$4.LEFT2 (PIN1)
unnamed: R4.2, U$4.RIGHT1 (PIN2), U$4.RIGHT2 (PIN2)
unnamed: C10.2, E1.25 (VCM)
unnamed: C11.2, E1.27 (VBG)
unnamed: C12.2, E1.23 (VREF)
RESET: S1.2, U$15.ICSP5 (RESET), U$15.RESET
SCL: I2C_SIDE.SCL, I2C_TOP.SCL, R2.1, U$15.SCL
SCLK: E1.16 (SCLK), U$15.ICSP3 (SCK)
SDA: I2C_SIDE.SDA, I2C_TOP.SDA, R1.1, U$15.SDA
VIN: U$15.VIN

Notes on the sheet:
1.0.0Beta1
DIGITAL (3pin Top 2mm pitch)
ANALOG (3pin Side 2mm pitch)
I2C (4pin 2mm pitch) x2
Software Serial RX
Software Serial TX
Serial (4pin 2mm pitch) Hard/Soft
Hardware Serial TX
Hardware Serial RX
I2C Pull-Up
RESET

Board: 2 copper layers, 68.6 x 53.3 mm, 49 parts (1 on the bottom side), 37 nets.

Other parts of the board:
U$2: LOGO_SILK_SERIAL2
U$3: LOGO_SILK_SERIAL
U$5, U$6: LOGO_SILK_PWM
U$11, U$12: LOGO_SILK_I2C

Notices in the files:
parts and their libraries:
FaBo-etc: Released under the Creative Commons Attribution-ShareAlike 4.0 License
https://creativecommons.org/licenses/by-sa/4.0
